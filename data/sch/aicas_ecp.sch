** sch_path: data/sch/aicas_ecp.sch
**.subckt aicas_ecp
RCP net1 11 10k m=1
RCN net1 21 10k m=1
IEE 13 2 0.1mA
**.ends
.end
