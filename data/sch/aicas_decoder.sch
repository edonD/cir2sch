v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {74145.sym} 520 -300 0 0 {name=X14}
T {X14} 500 -280 0 0 0.25 0.25 {}
C {devices/lab_pin.sym} 490 -360 0 0 {name=l_A sig_type=std_logic lab=A}
C {devices/lab_pin.sym} 550 -360 0 0 {name=l_B sig_type=std_logic lab=B}
C {devices/lab_pin.sym} 490 -340 0 0 {name=l_C sig_type=std_logic lab=C}
C {devices/lab_pin.sym} 550 -340 0 0 {name=l_D sig_type=std_logic lab=D}
C {devices/lab_pin.sym} 490 -320 0 0 {name=l_O0 sig_type=std_logic lab=O0}
C {devices/lab_pin.sym} 550 -320 0 0 {name=l_O1 sig_type=std_logic lab=O1}
C {devices/lab_pin.sym} 490 -300 0 0 {name=l_O2 sig_type=std_logic lab=O2}
C {devices/lab_pin.sym} 550 -300 0 0 {name=l_O3 sig_type=std_logic lab=O3}
C {devices/lab_pin.sym} 490 -280 0 0 {name=l_O4 sig_type=std_logic lab=O4}
C {devices/lab_pin.sym} 550 -280 0 0 {name=l_O5 sig_type=std_logic lab=O5}
C {devices/lab_pin.sym} 490 -260 0 0 {name=l_O6 sig_type=std_logic lab=O6}
C {devices/lab_pin.sym} 550 -260 0 0 {name=l_O7 sig_type=std_logic lab=O7}
C {devices/lab_pin.sym} 490 -240 0 0 {name=l_O8 sig_type=std_logic lab=O8}
C {devices/lab_pin.sym} 550 -240 0 0 {name=l_O9 sig_type=std_logic lab=O9}
