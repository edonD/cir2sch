** sch_path: data/sch/aicas_ex2a.sch
**.subckt aicas_ex2a
I1 7 GND -1mA
X1 7 GND sub1_in_lib
I2 net1 GND -1mA
X2 net1 GND sub2_in_lib
**.ends
.GLOBAL GND
.end
