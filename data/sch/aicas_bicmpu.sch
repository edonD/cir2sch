** sch_path: data/sch/aicas_bicmpu.sch
**.subckt aicas_bicmpu
M1 net1 3 5 net1 M_PMOS_1 w=10U l=1U m=1
CL 4 GND 5.0PF m=1
**.ends
.GLOBAL GND
.end
