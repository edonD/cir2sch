v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/nmos4.sym} 220 -150 0 0 {name=M1
w=4U
l=1U
model=M_NMOS_1}
C {devices/capa.sym} 440 -280 0 0 {name=CL
value=1PF}
C {devices/lab_pin.sym} 200 -150 0 0 {name=l_3 sig_type=std_logic lab=3}
C {devices/lab_pin.sym} 240 -180 0 0 {name=l_8 sig_type=std_logic lab=8}
C {devices/lab_pin.sym} 240 -120 0 0 {name=l_5 sig_type=std_logic lab=5}
C {devices/lab_pin.sym} 240 -150 0 0 {name=l_11 sig_type=std_logic lab=11}
C {devices/lab_pin.sym} 440 -310 0 0 {name=l_4 sig_type=std_logic lab=4}
C {devices/lab_pin.sym} 440 -250 0 0 {name=l_6 sig_type=std_logic lab=6}
