** sch_path: data/sch/aicas_eclinv.sch
**.subckt aicas_eclinv
R1 net1 5 662 m=1
R2 net1 6 662 m=1
R3 9 net2 2.65K m=1
R4 7 net2 4.06K m=1
R5 8 net2 4.06K m=1
**.ends
.end
