** sch_path: data/sch/aicas_ac-resistance.sch
**.subckt aicas_ac-resistance
check for proper use m=1
R1 1 1 1k m=1
C2 1 GND 1n m=1
R2 1 GND 4k m=1
**.ends
.GLOBAL GND
.end
