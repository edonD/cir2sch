** sch_path: data/sch/aicas_ac-zero.sch
**.subckt aicas_ac-zero
r1 1 2 1k m=1
r3 GND GND 1k m=1
c3 GND GND 1uF m=1
**.ends
.GLOBAL GND
.end
