** sch_path: data/sch/aicas_diotran.sch
**.subckt aicas_diotran
Vpp 3 GND 0.7v
Vnn 2 GND 0v
R1 3 3 1k m=1
**.ends
.GLOBAL GND
.end
