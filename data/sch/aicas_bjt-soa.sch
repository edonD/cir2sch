v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/isource.sym} 300 150 0 0 {name=Ib
value=-1u}
C {devices/gnd.sym} 300 180 0 0 {name=l_0 lab=GND}
C {devices/lab_pin.sym} 300 120 0 0 {name=l_b sig_type=std_logic lab=b}
