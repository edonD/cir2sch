v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/vsource.sym} 300 150 0 0 {name=Vce
value=-1}
C {devices/isource.sym} 430 150 0 0 {name=Ib
value=-1u}
C {devices/vsource.sym} 560 150 0 0 {name=Ve
value=0}
C {devices/lab_pin.sym} 300 120 0 0 {name=l_c sig_type=std_logic lab=c}
C {devices/gnd.sym} 300 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 180 0 0 {name=l_0 lab=GND}
C {devices/lab_pin.sym} 430 120 0 0 {name=l_b sig_type=std_logic lab=b}
C {devices/lab_pin.sym} 560 120 0 0 {name=l_e sig_type=std_logic lab=e}
