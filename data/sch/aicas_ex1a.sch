** sch_path: data/sch/aicas_ex1a.sch
**.subckt aicas_ex1a n1 n2
*.iopin n1
*.iopin n2
X2 net1 net2 sub_in_lib
R2 net1 net2 2k m=1
**.ends
.end
