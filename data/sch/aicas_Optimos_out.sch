v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {BSC0500NSI.sym} 660 -300 0 0 {name=Xopt}
C {devices/res.sym} 440 -280 0 0 {name=rd
value=6m}
T {Xopt} 640 -280 0 0 0.25 0.25 {}
N 630 -320 630 -250 {lab=Nvd}
N 630 -250 440 -250 {lab=Nvd}
C {devices/lab_pin.sym} 690 -320 0 0 {name=l_Nvg sig_type=std_logic lab=Nvg}
C {devices/lab_pin.sym} 630 -300 0 0 {name=l_Nvs sig_type=std_logic lab=Nvs}
C {devices/lab_pin.sym} 690 -300 0 0 {name=l_Tj sig_type=std_logic lab=Tj}
C {devices/lab_pin.sym} 630 -280 0 0 {name=l_Tcase sig_type=std_logic lab=Tcase}
C {devices/lab_pin.sym} 440 -310 0 0 {name=l_1 sig_type=std_logic lab=1}
