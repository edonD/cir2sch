** sch_path: data/sch/aicas_URC-TM-SUB.sch
**.subckt aicas_URC-TM-SUB
XUTM GND net1 GND UTM
VS GND GND 0
**.ends
.GLOBAL GND
.end
