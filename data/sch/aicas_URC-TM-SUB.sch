v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {UTM.sym} 520 -300 0 0 {name=XUTM}
T {XUTM} 500 -280 0 0 0.25 0.25 {}
C {devices/lab_pin.sym} 490 -320 0 0 {name=l_1 sig_type=std_logic lab=1}
C {devices/lab_pin.sym} 550 -320 0 0 {name=l_2 sig_type=std_logic lab=2}
C {devices/gnd.sym} 490 -300 0 0 {name=l_0 lab=GND}
