** sch_path: data/sch/aicas_ecpal.sch
**.subckt aicas_ecpal
VCC 1 GND 5V
VEE GND GND 0V
VINP 4 GND 2.99925V
VINM 7 GND 3V
IEE 5 GND 0.1MA
**.ends
.GLOBAL GND
.end
