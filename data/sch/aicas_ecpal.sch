v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/isource.sym} 300 150 0 0 {name=IEE
value=0.1MA}
C {devices/lab_pin.sym} 300 180 0 0 {name=l_2 sig_type=std_logic lab=2}
C {devices/lab_pin.sym} 300 120 0 0 {name=l_5 sig_type=std_logic lab=5}
