v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/vsource.sym} 110 90 0 0 {name=VDD0
value=0}
C {devices/vsource.sym} 240 90 0 0 {name=VSS0
value=0}
C {devices/vsource.sym} 370 90 0 0 {name=VDD_A0
value=0}
C {devices/vsource.sym} 500 90 0 0 {name=VSS_A0
value=0}
C {devices/vsource.sym} 110 220 0 0 {name=VDD_B0
value=0}
C {devices/vsource.sym} 240 220 0 0 {name=VSS_B0
value=0}
C {devices/res.sym} 1100 -60 0 0 {name=RA0
value=0.266535044422507}
C {devices/res.sym} 1240 -60 0 0 {name=RB0
value=0.266535044422507}
C {devices/capa.sym} 1030 -150 0 0 {name=C0
value=2.50418376625721e-14}
C {devices/nmos4.sym} 110 -150 0 0 {name=MNA0
w=
l=2.53696435353243e-07
model=Nmod}
C {devices/nmos4.sym} 390 -150 0 0 {name=MPA0
w=
l=2.55343565546106e-07
model=Pmod}
C {devices/nmos4.sym} 330 -150 0 1 {name=MNB0
w=
l=2.53941602497219e-07
model=Nmod}
C {devices/nmos4.sym} 610 -150 0 1 {name=MPB0
w=
l=2.52010168145607e-07
model=Pmod}
C {devices/res.sym} 1660 -60 0 0 {name=RA1
value=0.266535044422507}
C {devices/res.sym} 1800 -60 0 0 {name=RB1
value=0.266535044422507}
C {devices/capa.sym} 1590 -150 0 0 {name=C1
value=2.50418376625721e-14}
C {devices/nmos4.sym} 670 -150 0 0 {name=MNA1
w=4.12246995102289e-05
l=2.52370578161099e-07
model=Nmod}
C {devices/nmos4.sym} 950 -150 0 0 {name=MPA1
w=0.000103710764679465
l=2.45709468983316e-07
model=Pmod}
C {devices/nmos4.sym} 890 -150 0 1 {name=MNB1
w=4.26306134285554e-05
l=2.48115895523017e-07
model=Nmod}
C {devices/nmos4.sym} 1170 -150 0 1 {name=MPB1
w=0.000102043840486507
l=2.55265156192223e-07
model=Pmod}
C {devices/res.sym} 2220 -60 0 0 {name=RA2
value=0.266535044422507}
C {devices/res.sym} 2360 -60 0 0 {name=RB2
value=0.266535044422507}
C {devices/capa.sym} 2150 -150 0 0 {name=C2
value=2.50418376625721e-14}
C {devices/nmos4.sym} 1230 -150 0 0 {name=MNA2
w=4.16915225420459e-05
l=2.53484220592882e-07
model=Nmod}
C {devices/nmos4.sym} 1510 -150 0 0 {name=MPA2
w=0.00010549295960702
l=2.44256748076514e-07
model=Pmod}
C {devices/nmos4.sym} 1450 -150 0 1 {name=MNB2
w=4.15734692647458e-05
l=2.48805892712811e-07
model=Nmod}
C {devices/nmos4.sym} 1730 -150 0 1 {name=MPB2
w=0.00010229621219808
l=2.54004987710956e-07
model=Pmod}
C {devices/res.sym} 2780 -60 0 0 {name=RA3
value=0.266535044422507}
C {devices/res.sym} 2920 -60 0 0 {name=RB3
value=0.266535044422507}
C {devices/capa.sym} 2710 -150 0 0 {name=C3
value=2.50418376625721e-14}
C {devices/nmos4.sym} 1790 -150 0 0 {name=MNA3
w=4.11339076756089e-05
l=2.54307430347219e-07
model=Nmod}
C {devices/nmos4.sym} 2070 -150 0 0 {name=MPA3
w=0.000103371681055656
l=2.52369109463781e-07
model=Pmod}
C {devices/nmos4.sym} 2010 -150 0 1 {name=MNB3
w=4.21794611046917e-05
l=2.4960708801709e-07
model=Nmod}
C {devices/nmos4.sym} 2290 -150 0 1 {name=MPB3
w=0.000105556314711602
l=2.53834779766428e-07
model=Pmod}
C {devices/res.sym} 3340 -60 0 0 {name=RA4
value=0.266535044422507}
C {devices/res.sym} 3480 -60 0 0 {name=RB4
value=0.266535044422507}
C {devices/capa.sym} 3270 -150 0 0 {name=C4
value=2.50418376625721e-14}
C {devices/nmos4.sym} 2350 -150 0 0 {name=MNA4
w=4.11207568141106e-05
l=2.48091656083177e-07
model=Nmod}
C {devices/nmos4.sym} 2630 -150 0 0 {name=MPA4
w=0.000103463392309261
l=2.47723605289033e-07
model=Pmod}
C {devices/nmos4.sym} 2570 -150 0 1 {name=MNB4
w=4.25122425012226e-05
l=2.49254771880382e-07
model=Nmod}
C {devices/nmos4.sym} 2850 -150 0 1 {name=MPB4
w=0.000103227993619608
l=2.49689766979065e-07
model=Pmod}
C {devices/res.sym} 3900 -60 0 0 {name=RA5
value=0.266535044422507}
C {devices/res.sym} 4040 -60 0 0 {name=RB5
value=0.266535044422507}
C {devices/capa.sym} 3830 -150 0 0 {name=C5
value=2.50418376625721e-14}
C {devices/nmos4.sym} 2910 -150 0 0 {name=MNA5
w=4.1129961792588e-05
l=2.53960031106522e-07
model=Nmod}
C {devices/nmos4.sym} 3190 -150 0 0 {name=MPA5
w=0.000101621693062467
l=2.47418707088064e-07
model=Pmod}
C {devices/nmos4.sym} 3130 -150 0 1 {name=MNB5
w=4.2524931640785e-05
l=2.49659687529522e-07
model=Nmod}
C {devices/nmos4.sym} 3410 -150 0 1 {name=MPB5
w=0.000102061546065548
l=2.46328059754468e-07
model=Pmod}
C {devices/res.sym} 4460 -60 0 0 {name=RA6
value=0.266535044422507}
C {devices/res.sym} 4600 -60 0 0 {name=RB6
value=0.266535044422507}
C {devices/capa.sym} 4390 -150 0 0 {name=C6
value=2.50418376625721e-14}
C {devices/nmos4.sym} 3470 -150 0 0 {name=MNA6
w=4.17332976706085e-05
l=2.54326804653788e-07
model=Nmod}
C {devices/nmos4.sym} 3750 -150 0 0 {name=MPA6
w=0.000103244611103459
l=2.48727427835127e-07
model=Pmod}
C {devices/nmos4.sym} 3690 -150 0 1 {name=MNB6
w=4.23570035518e-05
l=2.49697035135609e-07
model=Nmod}
C {devices/nmos4.sym} 3970 -150 0 1 {name=MPB6
w=0.000103695454759978
l=2.48995485890626e-07
model=Pmod}
C {devices/res.sym} 4900 -60 0 0 {name=RA7
value=0.266535044422507}
C {devices/res.sym} 5140 -60 0 0 {name=RB7
value=0.266535044422507}
C {devices/capa.sym} 4880 -150 0 0 {name=C7
value=2.50418376625721e-14}
C {devices/nmos4.sym} 4030 -150 0 0 {name=MNA7
w=4.06421756574473e-05
l=2.53418975114981e-07
model=Nmod}
C {devices/nmos4.sym} 4310 -150 0 0 {name=MPA7
w=0.000104600862141835
l=2.4471861043622e-07
model=Pmod}
C {devices/nmos4.sym} 4250 -150 0 1 {name=MNB7
w=4.06845582724173e-05
l=2.50159056393584e-07
model=Nmod}
C {devices/nmos4.sym} 4530 -150 0 1 {name=MPB7
w=0.000106482118141681
l=2.55032245177227e-07
model=Pmod}
C {devices/res.sym} 5580 -60 0 0 {name=RA8
value=0.266535044422507}
C {devices/res.sym} 5720 -60 0 0 {name=RB8
value=0.266535044422507}
C {devices/capa.sym} 5510 -150 0 0 {name=C8
value=2.50418376625721e-14}
C {devices/nmos4.sym} 4590 -150 0 0 {name=MNA8
w=4.18266198665335e-05
l=2.45729547191971e-07
model=Nmod}
C {devices/nmos4.sym} 4870 -150 0 0 {name=MPA8
w=0.000101593205477244
l=2.45156004861421e-07
model=Pmod}
C {devices/nmos4.sym} 4810 -150 0 1 {name=MNB8
w=4.14314219478801e-05
l=2.49014342219656e-07
model=Nmod}
C {devices/nmos4.sym} 5090 -150 0 1 {name=MPB8
w=0.000103029640740115
l=2.50396673007567e-07
model=Pmod}
C {devices/res.sym} 6140 -60 0 0 {name=RA9
value=0.266535044422507}
C {devices/res.sym} 6280 -60 0 0 {name=RB9
value=0.266535044422507}
C {devices/capa.sym} 6070 -150 0 0 {name=C9
value=2.50418376625721e-14}
C {devices/nmos4.sym} 5150 -150 0 0 {name=MNA9
w=4.17044186844862e-05
l=2.51066307645916e-07
model=Nmod}
C {devices/nmos4.sym} 5430 -150 0 0 {name=MPA9
w=0.000104601836030031
l=2.4945438501494e-07
model=Pmod}
C {devices/nmos4.sym} 5370 -150 0 1 {name=MNB9
w=4.17990098329256e-05
l=2.56178041422984e-07
model=Nmod}
C {devices/nmos4.sym} 5650 -150 0 1 {name=MPB9
w=0.000103578149162769
l=2.5274010042983e-07
model=Pmod}
C {devices/res.sym} 6700 -60 0 0 {name=RA10
value=0.266535044422507}
C {devices/res.sym} 6840 -60 0 0 {name=RB10
value=0.266535044422507}
C {devices/capa.sym} 6630 -150 0 0 {name=C10
value=2.50418376625721e-14}
C {devices/nmos4.sym} 5710 -150 0 0 {name=MNA10
w=4.24345922952649e-05
l=2.45772611943267e-07
model=Nmod}
C {devices/nmos4.sym} 5990 -150 0 0 {name=MPA10
w=
l=2.55544710347746e-07
model=Pmod}
C {devices/nmos4.sym} 5930 -150 0 1 {name=MNB10
w=4.0850956346516e-05
l=2.55886308364338e-07
model=Nmod}
C {devices/nmos4.sym} 6210 -150 0 1 {name=MPB10
w=
l=2.44778614470725e-07
model=Pmod}
C {devices/res.sym} 7260 -60 0 0 {name=RA11
value=0.266535044422507}
C {devices/res.sym} 7400 -60 0 0 {name=RB11
value=0.266535044422507}
C {devices/capa.sym} 7190 -150 0 0 {name=C11
value=2.50418376625721e-14}
C {devices/nmos4.sym} 6270 -150 0 0 {name=MNA11
w=4.14724461551725e-05
l=2.4768739676619e-07
model=Nmod}
C {devices/nmos4.sym} 6550 -150 0 0 {name=MPA11
w=
l=2.46276216123912e-07
model=Pmod}
C {devices/nmos4.sym} 6490 -150 0 1 {name=MNB11
w=4.24608643314108e-05
l=2.54985612770668e-07
model=Nmod}
C {devices/nmos4.sym} 6770 -150 0 1 {name=MPB11
w=
l=2.45772463970764e-07
model=Pmod}
C {devices/res.sym} 7820 -60 0 0 {name=RA12
value=0.266535044422507}
C {devices/res.sym} 7960 -60 0 0 {name=RB12
value=0.266535044422507}
C {devices/capa.sym} 7750 -150 0 0 {name=C12
value=2.50418376625721e-14}
C {devices/nmos4.sym} 6830 -150 0 0 {name=MNA12
w=4.20858793029857e-05
l=2.45480481009462e-07
model=Nmod}
C {devices/nmos4.sym} 7110 -150 0 0 {name=MPA12
w=
l=2.48462320158069e-07
model=Pmod}
C {devices/nmos4.sym} 7050 -150 0 1 {name=MNB12
w=4.17981435096244e-05
l=2.51992945030792e-07
model=Nmod}
C {devices/nmos4.sym} 7330 -150 0 1 {name=MPB12
w=
l=2.49941922576661e-07
model=Pmod}
C {devices/res.sym} 8380 -60 0 0 {name=RA13
value=0.266535044422507}
C {devices/res.sym} 8520 -60 0 0 {name=RB13
value=0.266535044422507}
C {devices/capa.sym} 8310 -150 0 0 {name=C13
value=2.50418376625721e-14}
C {devices/nmos4.sym} 7390 -150 0 0 {name=MNA13
w=4.23276196447018e-05
l=2.51146190542173e-07
model=Nmod}
C {devices/nmos4.sym} 7670 -150 0 0 {name=MPA13
w=
l=2.46359362747576e-07
model=Pmod}
C {devices/nmos4.sym} 7610 -150 0 1 {name=MNB13
w=4.11044634633624e-05
l=2.44656485453628e-07
model=Nmod}
C {devices/nmos4.sym} 7890 -150 0 1 {name=MPB13
w=
l=2.56119611942636e-07
model=Pmod}
C {devices/res.sym} 8940 -60 0 0 {name=RA14
value=0.266535044422507}
C {devices/res.sym} 9080 -60 0 0 {name=RB14
value=0.266535044422507}
C {devices/capa.sym} 8870 -150 0 0 {name=C14
value=2.50418376625721e-14}
C {devices/nmos4.sym} 7950 -150 0 0 {name=MNA14
w=4.20889991075918e-05
l=2.47663439668801e-07
model=Nmod}
C {devices/nmos4.sym} 8230 -150 0 0 {name=MPA14
w=
l=2.51252450429323e-07
model=Pmod}
C {devices/nmos4.sym} 8170 -150 0 1 {name=MNB14
w=4.24685059762319e-05
l=2.5044796612668e-07
model=Nmod}
C {devices/nmos4.sym} 8450 -150 0 1 {name=MPB14
w=
l=2.4786360459861e-07
model=Pmod}
C {devices/res.sym} 9500 -60 0 0 {name=RA15
value=0.266535044422507}
C {devices/res.sym} 9640 -60 0 0 {name=RB15
value=0.266535044422507}
C {devices/capa.sym} 9430 -150 0 0 {name=C15
value=2.50418376625721e-14}
C {devices/nmos4.sym} 8510 -150 0 0 {name=MNA15
w=4.26610931467994e-05
l=2.5213362488047e-07
model=Nmod}
C {devices/nmos4.sym} 8790 -150 0 0 {name=MPA15
w=
l=2.44411053097269e-07
model=Pmod}
C {devices/nmos4.sym} 8730 -150 0 1 {name=MNB15
w=4.18061319080677e-05
l=2.44947739168727e-07
model=Nmod}
C {devices/nmos4.sym} 9010 -150 0 1 {name=MPB15
w=
l=2.45133067349567e-07
model=Pmod}
C {devices/res.sym} 10060 -60 0 0 {name=RA16
value=0.266535044422507}
C {devices/res.sym} 10200 -60 0 0 {name=RB16
value=0.266535044422507}
C {devices/capa.sym} 9990 -150 0 0 {name=C16
value=2.50418376625721e-14}
C {devices/nmos4.sym} 9070 -150 0 0 {name=MNA16
w=4.23651981762607e-05
l=2.5558903414348e-07
model=Nmod}
C {devices/nmos4.sym} 9350 -150 0 0 {name=MPA16
w=
l=2.46968507923118e-07
model=Pmod}
C {devices/nmos4.sym} 9290 -150 0 1 {name=MNB16
w=4.0963445615255e-05
l=2.52441475326891e-07
model=Nmod}
C {devices/nmos4.sym} 9570 -150 0 1 {name=MPB16
w=
l=2.49958772476576e-07
model=Pmod}
C {devices/res.sym} 10620 -60 0 0 {name=RA17
value=0.266535044422507}
C {devices/res.sym} 10760 -60 0 0 {name=RB17
value=0.266535044422507}
C {devices/capa.sym} 10550 -150 0 0 {name=C17
value=2.50418376625721e-14}
C {devices/nmos4.sym} 9630 -150 0 0 {name=MNA17
w=4.07033737509309e-05
l=2.46623947628415e-07
model=Nmod}
C {devices/nmos4.sym} 9910 -150 0 0 {name=MPA17
w=
l=2.52274212428759e-07
model=Pmod}
C {devices/nmos4.sym} 9850 -150 0 1 {name=MNB17
w=4.12815452669714e-05
l=2.51233452024547e-07
model=Nmod}
C {devices/nmos4.sym} 10130 -150 0 1 {name=MPB17
w=
l=2.49324495416238e-07
model=Pmod}
C {devices/res.sym} 11180 -60 0 0 {name=RA18
value=0.266535044422507}
C {devices/res.sym} 11320 -60 0 0 {name=RB18
value=0.266535044422507}
C {devices/capa.sym} 11110 -150 0 0 {name=C18
value=2.50418376625721e-14}
C {devices/nmos4.sym} 10190 -150 0 0 {name=MNA18
w=4.17044670825126e-05
l=2.52038203439398e-07
model=Nmod}
C {devices/nmos4.sym} 10470 -150 0 0 {name=MPA18
w=
l=2.46465042965348e-07
model=Pmod}
C {devices/nmos4.sym} 10410 -150 0 1 {name=MNB18
w=4.2510656912981e-05
l=2.45695550122768e-07
model=Nmod}
C {devices/nmos4.sym} 10690 -150 0 1 {name=MPB18
w=
l=2.56212134001568e-07
model=Pmod}
C {devices/res.sym} 11740 -60 0 0 {name=RA19
value=0.266535044422507}
C {devices/res.sym} 11880 -60 0 0 {name=RB19
value=0.266535044422507}
C {devices/capa.sym} 11670 -150 0 0 {name=C19
value=2.50418376625721e-14}
C {devices/nmos4.sym} 10750 -150 0 0 {name=MNA19
w=4.26183323927543e-05
l=2.46298724559332e-07
model=Nmod}
C {devices/nmos4.sym} 11030 -150 0 0 {name=MPA19
w=
l=2.53903413760174e-07
model=Pmod}
C {devices/nmos4.sym} 10970 -150 0 1 {name=MNB19
w=4.1471197163819e-05
l=2.4541336381424e-07
model=Nmod}
C {devices/nmos4.sym} 11250 -150 0 1 {name=MPB19
w=
l=2.51953325753565e-07
model=Pmod}
C {devices/res.sym} 12300 -60 0 0 {name=RA20
value=0.266535044422507}
C {devices/res.sym} 12440 -60 0 0 {name=RB20
value=0.266535044422507}
C {devices/capa.sym} 12230 -150 0 0 {name=C20
value=2.50418376625721e-14}
C {devices/nmos4.sym} 11310 -150 0 0 {name=MNA20
w=4.2257523363596e-05
l=2.55318350883171e-07
model=Nmod}
C {devices/nmos4.sym} 11590 -150 0 0 {name=MPA20
w=
l=2.50733395598687e-07
model=Pmod}
C {devices/nmos4.sym} 11530 -150 0 1 {name=MNB20
w=4.07467605160825e-05
l=2.53961238224852e-07
model=Nmod}
C {devices/nmos4.sym} 11810 -150 0 1 {name=MPB20
w=
l=2.52173406118976e-07
model=Pmod}
C {devices/res.sym} 12860 -60 0 0 {name=RA21
value=0.266535044422507}
C {devices/res.sym} 13000 -60 0 0 {name=RB21
value=0.266535044422507}
C {devices/capa.sym} 12790 -150 0 0 {name=C21
value=2.50418376625721e-14}
C {devices/nmos4.sym} 11870 -150 0 0 {name=MNA21
w=4.1601573531982e-05
l=2.46323292867561e-07
model=Nmod}
C {devices/nmos4.sym} 12150 -150 0 0 {name=MPA21
w=
l=2.54613442115316e-07
model=Pmod}
C {devices/nmos4.sym} 12090 -150 0 1 {name=MNB21
w=4.10424160274173e-05
l=2.55836584454404e-07
model=Nmod}
C {devices/nmos4.sym} 12370 -150 0 1 {name=MPB21
w=
l=2.54709741956022e-07
model=Pmod}
C {devices/res.sym} 13420 -60 0 0 {name=RA22
value=0.266535044422507}
C {devices/res.sym} 13560 -60 0 0 {name=RB22
value=0.266535044422507}
C {devices/capa.sym} 13350 -150 0 0 {name=C22
value=2.50418376625721e-14}
C {devices/nmos4.sym} 12430 -150 0 0 {name=MNA22
w=4.19307535657001e-05
l=2.54430620981417e-07
model=Nmod}
C {devices/nmos4.sym} 12710 -150 0 0 {name=MPA22
w=
l=2.46694525572975e-07
model=Pmod}
C {devices/nmos4.sym} 12650 -150 0 1 {name=MNB22
w=4.12343575509987e-05
l=2.4991048194413e-07
model=Nmod}
C {devices/nmos4.sym} 12930 -150 0 1 {name=MPB22
w=
l=2.53435790976082e-07
model=Pmod}
C {devices/res.sym} 13710 -280 0 0 {name=RA23
value=0.266535044422507}
C {devices/res.sym} 13930 -280 0 0 {name=RB23
value=0.266535044422507}
C {devices/capa.sym} 14040 -190 0 0 {name=C23
value=2.50418376625721e-14}
C {devices/nmos4.sym} 12990 -150 0 0 {name=MNA23
w=4.14939059451511e-05
l=2.47985427798248e-07
model=Nmod}
C {devices/nmos4.sym} 13270 -150 0 0 {name=MPA23
w=
l=2.50625862917368e-07
model=Pmod}
C {devices/nmos4.sym} 13210 -150 0 1 {name=MNB23
w=4.09072154111792e-05
l=2.48906363214973e-07
model=Nmod}
C {devices/nmos4.sym} 13490 -150 0 1 {name=MPB23
w=
l=2.544246792556e-07
model=Pmod}
C {devices/res.sym} 5260 -90 0 0 {name=RCROSS1
value=0.001}
C {devices/res.sym} 5000 -90 0 0 {name=RCROSS2
value=0.001}
C {devices/vsource.sym} 370 220 0 0 {name=VSLEW_CONTROL
value=(PULSE}
C {devices/vsource.sym} 500 220 0 0 {name=VDDPOWER
value=0}
C {devices/vsource.sym} 110 350 0 0 {name=VARACTOR_V
value=2.5}
N 240 60 240 250 {lab=VSS0}
N 240 60 240 120 {lab=VSS0}
N 240 120 500 120 {lab=VSS0}
N 370 60 370 -120 {lab=VDD_A0}
N 370 -120 590 -120 {lab=VDD_A0}
N 590 -120 590 -150 {lab=VDD_A0}
N 500 60 500 -120 {lab=VSS_A0}
N 500 -120 310 -120 {lab=VSS_A0}
N 310 -120 310 -150 {lab=VSS_A0}
N 110 190 110 -120 {lab=VDD_B0}
N 110 -120 410 -120 {lab=VDD_B0}
N 410 -120 410 -150 {lab=VDD_B0}
N 240 190 240 -120 {lab=VSS_B0}
N 240 -120 130 -120 {lab=VSS_B0}
N 130 -120 130 -150 {lab=VSS_B0}
N 1100 -30 1100 -180 {lab=A1}
N 1100 -180 1150 -180 {lab=A1}
N 1150 -180 1030 -180 {lab=A1}
N 1030 -180 1030 -150 {lab=A1}
N 1030 -150 930 -150 {lab=A1}
N 930 -150 930 -180 {lab=A1}
N 930 -180 870 -180 {lab=A1}
N 870 -180 870 -150 {lab=A1}
N 870 -150 650 -150 {lab=A1}
N 1240 -30 1240 -150 {lab=B1}
N 1240 -150 1190 -150 {lab=B1}
N 1190 -150 1190 -120 {lab=B1}
N 1190 -120 1030 -120 {lab=B1}
N 1030 -120 1030 -180 {lab=B1}
N 1030 -180 970 -180 {lab=B1}
N 970 -180 970 -150 {lab=B1}
N 970 -150 910 -150 {lab=B1}
N 910 -150 910 -180 {lab=B1}
N 910 -180 690 -180 {lab=B1}
N 130 -180 130 -150 {lab=B0}
N 130 -150 350 -150 {lab=B0}
N 350 -150 350 -180 {lab=B0}
N 350 -180 410 -180 {lab=B0}
N 410 -180 410 -150 {lab=B0}
N 410 -150 630 -150 {lab=B0}
N 90 -150 90 -180 {lab=A0}
N 90 -180 310 -180 {lab=A0}
N 310 -180 310 -150 {lab=A0}
N 310 -150 370 -150 {lab=A0}
N 370 -150 370 -180 {lab=A0}
N 370 -180 590 -180 {lab=A0}
N 1660 -30 1660 -180 {lab=A2}
N 1660 -180 1710 -180 {lab=A2}
N 1710 -180 1590 -180 {lab=A2}
N 1590 -180 1590 -150 {lab=A2}
N 1590 -150 1490 -150 {lab=A2}
N 1490 -150 1490 -180 {lab=A2}
N 1490 -180 1430 -180 {lab=A2}
N 1430 -180 1430 -150 {lab=A2}
N 1430 -150 1210 -150 {lab=A2}
N 1800 -30 1800 -150 {lab=B2}
N 1800 -150 1750 -150 {lab=B2}
N 1750 -150 1750 -120 {lab=B2}
N 1750 -120 1590 -120 {lab=B2}
N 1590 -120 1590 -180 {lab=B2}
N 1590 -180 1530 -180 {lab=B2}
N 1530 -180 1530 -150 {lab=B2}
N 1530 -150 1470 -150 {lab=B2}
N 1470 -150 1470 -180 {lab=B2}
N 1470 -180 1250 -180 {lab=B2}
N 2220 -30 2220 -180 {lab=A3}
N 2220 -180 2270 -180 {lab=A3}
N 2270 -180 2150 -180 {lab=A3}
N 2150 -180 2150 -150 {lab=A3}
N 2150 -150 2050 -150 {lab=A3}
N 2050 -150 2050 -180 {lab=A3}
N 2050 -180 1990 -180 {lab=A3}
N 1990 -180 1990 -150 {lab=A3}
N 1990 -150 1770 -150 {lab=A3}
N 2360 -30 2360 -150 {lab=B3}
N 2360 -150 2310 -150 {lab=B3}
N 2310 -150 2310 -120 {lab=B3}
N 2310 -120 2150 -120 {lab=B3}
N 2150 -120 2150 -180 {lab=B3}
N 2150 -180 2090 -180 {lab=B3}
N 2090 -180 2090 -150 {lab=B3}
N 2090 -150 2030 -150 {lab=B3}
N 2030 -150 2030 -180 {lab=B3}
N 2030 -180 1810 -180 {lab=B3}
N 2780 -30 2780 -180 {lab=A4}
N 2780 -180 2830 -180 {lab=A4}
N 2830 -180 2710 -180 {lab=A4}
N 2710 -180 2710 -150 {lab=A4}
N 2710 -150 2610 -150 {lab=A4}
N 2610 -150 2610 -180 {lab=A4}
N 2610 -180 2550 -180 {lab=A4}
N 2550 -180 2550 -150 {lab=A4}
N 2550 -150 2330 -150 {lab=A4}
N 2920 -30 2920 -150 {lab=B4}
N 2920 -150 2870 -150 {lab=B4}
N 2870 -150 2870 -120 {lab=B4}
N 2870 -120 2710 -120 {lab=B4}
N 2710 -120 2710 -180 {lab=B4}
N 2710 -180 2650 -180 {lab=B4}
N 2650 -180 2650 -150 {lab=B4}
N 2650 -150 2590 -150 {lab=B4}
N 2590 -150 2590 -180 {lab=B4}
N 2590 -180 2370 -180 {lab=B4}
N 3340 -30 3340 -180 {lab=A5}
N 3340 -180 3390 -180 {lab=A5}
N 3390 -180 3270 -180 {lab=A5}
N 3270 -180 3270 -150 {lab=A5}
N 3270 -150 3170 -150 {lab=A5}
N 3170 -150 3170 -180 {lab=A5}
N 3170 -180 3110 -180 {lab=A5}
N 3110 -180 3110 -150 {lab=A5}
N 3110 -150 2890 -150 {lab=A5}
N 3480 -30 3480 -150 {lab=B5}
N 3480 -150 3430 -150 {lab=B5}
N 3430 -150 3430 -120 {lab=B5}
N 3430 -120 3270 -120 {lab=B5}
N 3270 -120 3270 -180 {lab=B5}
N 3270 -180 3210 -180 {lab=B5}
N 3210 -180 3210 -150 {lab=B5}
N 3210 -150 3150 -150 {lab=B5}
N 3150 -150 3150 -180 {lab=B5}
N 3150 -180 2930 -180 {lab=B5}
N 3900 -30 3900 -180 {lab=A6}
N 3900 -180 3950 -180 {lab=A6}
N 3950 -180 3830 -180 {lab=A6}
N 3830 -180 3830 -150 {lab=A6}
N 3830 -150 3730 -150 {lab=A6}
N 3730 -150 3730 -180 {lab=A6}
N 3730 -180 3670 -180 {lab=A6}
N 3670 -180 3670 -150 {lab=A6}
N 3670 -150 3450 -150 {lab=A6}
N 4040 -30 4040 -150 {lab=B6}
N 4040 -150 3990 -150 {lab=B6}
N 3990 -150 3990 -120 {lab=B6}
N 3990 -120 3830 -120 {lab=B6}
N 3830 -120 3830 -180 {lab=B6}
N 3830 -180 3770 -180 {lab=B6}
N 3770 -180 3770 -150 {lab=B6}
N 3770 -150 3710 -150 {lab=B6}
N 3710 -150 3710 -180 {lab=B6}
N 3710 -180 3490 -180 {lab=B6}
N 4460 -30 4460 -180 {lab=A7}
N 4460 -180 4510 -180 {lab=A7}
N 4510 -180 4390 -180 {lab=A7}
N 4390 -180 4390 -150 {lab=A7}
N 4390 -150 4290 -150 {lab=A7}
N 4290 -150 4290 -180 {lab=A7}
N 4290 -180 4230 -180 {lab=A7}
N 4230 -180 4230 -150 {lab=A7}
N 4230 -150 4010 -150 {lab=A7}
N 4600 -30 4600 -150 {lab=B7}
N 4600 -150 4550 -150 {lab=B7}
N 4550 -150 4550 -120 {lab=B7}
N 4550 -120 4390 -120 {lab=B7}
N 4390 -120 4390 -180 {lab=B7}
N 4390 -180 4330 -180 {lab=B7}
N 4330 -180 4330 -150 {lab=B7}
N 4330 -150 4270 -150 {lab=B7}
N 4270 -150 4270 -180 {lab=B7}
N 4270 -180 4050 -180 {lab=B7}
N 4900 -30 4900 -180 {lab=A8}
N 4900 -180 4880 -180 {lab=A8}
N 4880 -180 4880 -150 {lab=A8}
N 4880 -150 4850 -150 {lab=A8}
N 4880 -180 4790 -180 {lab=A8}
N 4880 -180 5070 -180 {lab=A8}
N 4790 -180 4790 -150 {lab=A8}
N 4790 -150 4570 -150 {lab=A8}
N 5140 -30 5140 -150 {lab=B8}
N 5140 -150 5110 -150 {lab=B8}
N 5110 -150 5110 -180 {lab=B8}
N 5110 -180 4890 -180 {lab=B8}
N 4890 -180 4890 -120 {lab=B8}
N 4890 -120 4880 -120 {lab=B8}
N 4880 -120 4880 -150 {lab=B8}
N 4880 -150 4830 -150 {lab=B8}
N 4830 -150 4830 -180 {lab=B8}
N 4830 -180 4610 -180 {lab=B8}
N 5580 -30 5580 -180 {lab=A9}
N 5580 -180 5630 -180 {lab=A9}
N 5630 -180 5510 -180 {lab=A9}
N 5510 -180 5510 -150 {lab=A9}
N 5510 -150 5410 -150 {lab=A9}
N 5410 -150 5410 -180 {lab=A9}
N 5410 -180 5350 -180 {lab=A9}
N 5350 -180 5350 -150 {lab=A9}
N 5350 -150 5130 -150 {lab=A9}
N 5720 -30 5720 -150 {lab=B9}
N 5720 -150 5670 -150 {lab=B9}
N 5670 -150 5670 -120 {lab=B9}
N 5670 -120 5510 -120 {lab=B9}
N 5510 -120 5510 -180 {lab=B9}
N 5510 -180 5450 -180 {lab=B9}
N 5450 -180 5450 -150 {lab=B9}
N 5450 -150 5390 -150 {lab=B9}
N 5390 -150 5390 -180 {lab=B9}
N 5390 -180 5170 -180 {lab=B9}
N 6140 -30 6140 -180 {lab=A10}
N 6140 -180 6190 -180 {lab=A10}
N 6190 -180 6070 -180 {lab=A10}
N 6070 -180 6070 -150 {lab=A10}
N 6070 -150 5970 -150 {lab=A10}
N 5970 -150 5970 -180 {lab=A10}
N 5970 -180 5910 -180 {lab=A10}
N 5910 -180 5910 -150 {lab=A10}
N 5910 -150 5690 -150 {lab=A10}
N 6280 -30 6280 -150 {lab=B10}
N 6280 -150 6230 -150 {lab=B10}
N 6230 -150 6230 -120 {lab=B10}
N 6230 -120 6070 -120 {lab=B10}
N 6070 -120 6070 -180 {lab=B10}
N 6070 -180 6010 -180 {lab=B10}
N 6010 -180 6010 -150 {lab=B10}
N 6010 -150 5950 -150 {lab=B10}
N 5950 -150 5950 -180 {lab=B10}
N 5950 -180 5730 -180 {lab=B10}
N 6700 -30 6700 -180 {lab=A11}
N 6700 -180 6750 -180 {lab=A11}
N 6750 -180 6630 -180 {lab=A11}
N 6630 -180 6630 -150 {lab=A11}
N 6630 -150 6530 -150 {lab=A11}
N 6530 -150 6530 -180 {lab=A11}
N 6530 -180 6470 -180 {lab=A11}
N 6470 -180 6470 -150 {lab=A11}
N 6470 -150 6250 -150 {lab=A11}
N 6840 -30 6840 -150 {lab=B11}
N 6840 -150 6790 -150 {lab=B11}
N 6790 -150 6790 -120 {lab=B11}
N 6790 -120 6630 -120 {lab=B11}
N 6630 -120 6630 -180 {lab=B11}
N 6630 -180 6570 -180 {lab=B11}
N 6570 -180 6570 -150 {lab=B11}
N 6570 -150 6510 -150 {lab=B11}
N 6510 -150 6510 -180 {lab=B11}
N 6510 -180 6290 -180 {lab=B11}
N 7260 -30 7260 -180 {lab=A12}
N 7260 -180 7310 -180 {lab=A12}
N 7310 -180 7190 -180 {lab=A12}
N 7190 -180 7190 -150 {lab=A12}
N 7190 -150 7090 -150 {lab=A12}
N 7090 -150 7090 -180 {lab=A12}
N 7090 -180 7030 -180 {lab=A12}
N 7030 -180 7030 -150 {lab=A12}
N 7030 -150 6810 -150 {lab=A12}
N 7400 -30 7400 -150 {lab=B12}
N 7400 -150 7350 -150 {lab=B12}
N 7350 -150 7350 -120 {lab=B12}
N 7350 -120 7190 -120 {lab=B12}
N 7190 -120 7190 -180 {lab=B12}
N 7190 -180 7130 -180 {lab=B12}
N 7130 -180 7130 -150 {lab=B12}
N 7130 -150 7070 -150 {lab=B12}
N 7070 -150 7070 -180 {lab=B12}
N 7070 -180 6850 -180 {lab=B12}
N 7820 -30 7820 -180 {lab=A13}
N 7820 -180 7870 -180 {lab=A13}
N 7870 -180 7750 -180 {lab=A13}
N 7750 -180 7750 -150 {lab=A13}
N 7750 -150 7650 -150 {lab=A13}
N 7650 -150 7650 -180 {lab=A13}
N 7650 -180 7590 -180 {lab=A13}
N 7590 -180 7590 -150 {lab=A13}
N 7590 -150 7370 -150 {lab=A13}
N 7960 -30 7960 -150 {lab=B13}
N 7960 -150 7910 -150 {lab=B13}
N 7910 -150 7910 -120 {lab=B13}
N 7910 -120 7750 -120 {lab=B13}
N 7750 -120 7750 -180 {lab=B13}
N 7750 -180 7690 -180 {lab=B13}
N 7690 -180 7690 -150 {lab=B13}
N 7690 -150 7630 -150 {lab=B13}
N 7630 -150 7630 -180 {lab=B13}
N 7630 -180 7410 -180 {lab=B13}
N 8380 -30 8380 -180 {lab=A14}
N 8380 -180 8430 -180 {lab=A14}
N 8430 -180 8310 -180 {lab=A14}
N 8310 -180 8310 -150 {lab=A14}
N 8310 -150 8210 -150 {lab=A14}
N 8210 -150 8210 -180 {lab=A14}
N 8210 -180 8150 -180 {lab=A14}
N 8150 -180 8150 -150 {lab=A14}
N 8150 -150 7930 -150 {lab=A14}
N 8520 -30 8520 -150 {lab=B14}
N 8520 -150 8470 -150 {lab=B14}
N 8470 -150 8470 -120 {lab=B14}
N 8470 -120 8310 -120 {lab=B14}
N 8310 -120 8310 -180 {lab=B14}
N 8310 -180 8250 -180 {lab=B14}
N 8250 -180 8250 -150 {lab=B14}
N 8250 -150 8190 -150 {lab=B14}
N 8190 -150 8190 -180 {lab=B14}
N 8190 -180 7970 -180 {lab=B14}
N 8940 -30 8940 -180 {lab=A15}
N 8940 -180 8990 -180 {lab=A15}
N 8990 -180 8870 -180 {lab=A15}
N 8870 -180 8870 -150 {lab=A15}
N 8870 -150 8770 -150 {lab=A15}
N 8770 -150 8770 -180 {lab=A15}
N 8770 -180 8710 -180 {lab=A15}
N 8710 -180 8710 -150 {lab=A15}
N 8710 -150 8490 -150 {lab=A15}
N 9080 -30 9080 -150 {lab=B15}
N 9080 -150 9030 -150 {lab=B15}
N 9030 -150 9030 -120 {lab=B15}
N 9030 -120 8870 -120 {lab=B15}
N 8870 -120 8870 -180 {lab=B15}
N 8870 -180 8810 -180 {lab=B15}
N 8810 -180 8810 -150 {lab=B15}
N 8810 -150 8750 -150 {lab=B15}
N 8750 -150 8750 -180 {lab=B15}
N 8750 -180 8530 -180 {lab=B15}
N 9500 -30 9500 -180 {lab=A16}
N 9500 -180 9550 -180 {lab=A16}
N 9550 -180 9430 -180 {lab=A16}
N 9430 -180 9430 -150 {lab=A16}
N 9430 -150 9330 -150 {lab=A16}
N 9330 -150 9330 -180 {lab=A16}
N 9330 -180 9270 -180 {lab=A16}
N 9270 -180 9270 -150 {lab=A16}
N 9270 -150 9050 -150 {lab=A16}
N 9640 -30 9640 -150 {lab=B16}
N 9640 -150 9590 -150 {lab=B16}
N 9590 -150 9590 -120 {lab=B16}
N 9590 -120 9430 -120 {lab=B16}
N 9430 -120 9430 -180 {lab=B16}
N 9430 -180 9370 -180 {lab=B16}
N 9370 -180 9370 -150 {lab=B16}
N 9370 -150 9310 -150 {lab=B16}
N 9310 -150 9310 -180 {lab=B16}
N 9310 -180 9090 -180 {lab=B16}
N 10060 -30 10060 -180 {lab=A17}
N 10060 -180 10110 -180 {lab=A17}
N 10110 -180 9990 -180 {lab=A17}
N 9990 -180 9990 -150 {lab=A17}
N 9990 -150 9890 -150 {lab=A17}
N 9890 -150 9890 -180 {lab=A17}
N 9890 -180 9830 -180 {lab=A17}
N 9830 -180 9830 -150 {lab=A17}
N 9830 -150 9610 -150 {lab=A17}
N 10200 -30 10200 -150 {lab=B17}
N 10200 -150 10150 -150 {lab=B17}
N 10150 -150 10150 -120 {lab=B17}
N 10150 -120 9990 -120 {lab=B17}
N 9990 -120 9990 -180 {lab=B17}
N 9990 -180 9930 -180 {lab=B17}
N 9930 -180 9930 -150 {lab=B17}
N 9930 -150 9870 -150 {lab=B17}
N 9870 -150 9870 -180 {lab=B17}
N 9870 -180 9650 -180 {lab=B17}
N 10620 -30 10620 -180 {lab=A18}
N 10620 -180 10670 -180 {lab=A18}
N 10670 -180 10550 -180 {lab=A18}
N 10550 -180 10550 -150 {lab=A18}
N 10550 -150 10450 -150 {lab=A18}
N 10450 -150 10450 -180 {lab=A18}
N 10450 -180 10390 -180 {lab=A18}
N 10390 -180 10390 -150 {lab=A18}
N 10390 -150 10170 -150 {lab=A18}
N 10760 -30 10760 -150 {lab=B18}
N 10760 -150 10710 -150 {lab=B18}
N 10710 -150 10710 -120 {lab=B18}
N 10710 -120 10550 -120 {lab=B18}
N 10550 -120 10550 -180 {lab=B18}
N 10550 -180 10490 -180 {lab=B18}
N 10490 -180 10490 -150 {lab=B18}
N 10490 -150 10430 -150 {lab=B18}
N 10430 -150 10430 -180 {lab=B18}
N 10430 -180 10210 -180 {lab=B18}
N 11180 -30 11180 -180 {lab=A19}
N 11180 -180 11230 -180 {lab=A19}
N 11230 -180 11110 -180 {lab=A19}
N 11110 -180 11110 -150 {lab=A19}
N 11110 -150 11010 -150 {lab=A19}
N 11010 -150 11010 -180 {lab=A19}
N 11010 -180 10950 -180 {lab=A19}
N 10950 -180 10950 -150 {lab=A19}
N 10950 -150 10730 -150 {lab=A19}
N 11320 -30 11320 -150 {lab=B19}
N 11320 -150 11270 -150 {lab=B19}
N 11270 -150 11270 -120 {lab=B19}
N 11270 -120 11110 -120 {lab=B19}
N 11110 -120 11110 -180 {lab=B19}
N 11110 -180 11050 -180 {lab=B19}
N 11050 -180 11050 -150 {lab=B19}
N 11050 -150 10990 -150 {lab=B19}
N 10990 -150 10990 -180 {lab=B19}
N 10990 -180 10770 -180 {lab=B19}
N 11740 -30 11740 -180 {lab=A20}
N 11740 -180 11790 -180 {lab=A20}
N 11790 -180 11670 -180 {lab=A20}
N 11670 -180 11670 -150 {lab=A20}
N 11670 -150 11570 -150 {lab=A20}
N 11570 -150 11570 -180 {lab=A20}
N 11570 -180 11510 -180 {lab=A20}
N 11510 -180 11510 -150 {lab=A20}
N 11510 -150 11290 -150 {lab=A20}
N 11880 -30 11880 -150 {lab=B20}
N 11880 -150 11830 -150 {lab=B20}
N 11830 -150 11830 -120 {lab=B20}
N 11830 -120 11670 -120 {lab=B20}
N 11670 -120 11670 -180 {lab=B20}
N 11670 -180 11610 -180 {lab=B20}
N 11610 -180 11610 -150 {lab=B20}
N 11610 -150 11550 -150 {lab=B20}
N 11550 -150 11550 -180 {lab=B20}
N 11550 -180 11330 -180 {lab=B20}
N 12300 -30 12300 -180 {lab=A21}
N 12300 -180 12350 -180 {lab=A21}
N 12350 -180 12230 -180 {lab=A21}
N 12230 -180 12230 -150 {lab=A21}
N 12230 -150 12130 -150 {lab=A21}
N 12130 -150 12130 -180 {lab=A21}
N 12130 -180 12070 -180 {lab=A21}
N 12070 -180 12070 -150 {lab=A21}
N 12070 -150 11850 -150 {lab=A21}
N 12440 -30 12440 -150 {lab=B21}
N 12440 -150 12390 -150 {lab=B21}
N 12390 -150 12390 -120 {lab=B21}
N 12390 -120 12230 -120 {lab=B21}
N 12230 -120 12230 -180 {lab=B21}
N 12230 -180 12170 -180 {lab=B21}
N 12170 -180 12170 -150 {lab=B21}
N 12170 -150 12110 -150 {lab=B21}
N 12110 -150 12110 -180 {lab=B21}
N 12110 -180 11890 -180 {lab=B21}
N 12860 -30 12860 -180 {lab=A22}
N 12860 -180 12910 -180 {lab=A22}
N 12910 -180 12790 -180 {lab=A22}
N 12790 -180 12790 -150 {lab=A22}
N 12790 -150 12690 -150 {lab=A22}
N 12690 -150 12690 -180 {lab=A22}
N 12690 -180 12630 -180 {lab=A22}
N 12630 -180 12630 -150 {lab=A22}
N 12630 -150 12410 -150 {lab=A22}
N 13000 -30 13000 -150 {lab=B22}
N 13000 -150 12950 -150 {lab=B22}
N 12950 -150 12950 -120 {lab=B22}
N 12950 -120 12790 -120 {lab=B22}
N 12790 -120 12790 -180 {lab=B22}
N 12790 -180 12730 -180 {lab=B22}
N 12730 -180 12730 -150 {lab=B22}
N 12730 -150 12670 -150 {lab=B22}
N 12670 -150 12670 -180 {lab=B22}
N 12670 -180 12450 -180 {lab=B22}
N 13420 -30 13420 -180 {lab=A23}
N 13420 -180 13470 -180 {lab=A23}
N 13470 -180 13350 -180 {lab=A23}
N 13350 -180 13350 -150 {lab=A23}
N 13350 -150 13250 -150 {lab=A23}
N 13250 -150 13250 -180 {lab=A23}
N 13250 -180 13190 -180 {lab=A23}
N 13190 -180 13190 -150 {lab=A23}
N 13190 -150 12970 -150 {lab=A23}
N 13560 -30 13560 -150 {lab=B23}
N 13560 -150 13510 -150 {lab=B23}
N 13510 -150 13510 -120 {lab=B23}
N 13510 -120 13350 -120 {lab=B23}
N 13350 -120 13350 -180 {lab=B23}
N 13350 -180 13290 -180 {lab=B23}
N 13290 -180 13290 -150 {lab=B23}
N 13290 -150 13230 -150 {lab=B23}
N 13230 -150 13230 -180 {lab=B23}
N 13230 -180 13010 -180 {lab=B23}
N 13930 -250 13930 -160 {lab=B24}
N 13930 -160 14040 -160 {lab=B24}
C {devices/vdd.sym} 110 120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 970 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 970 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 1150 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 1150 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 1530 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 1530 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 1710 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 1710 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 2090 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 2090 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 2270 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 2270 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 2650 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 2650 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 2830 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 2830 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 3210 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 3210 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 3390 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 3390 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 3770 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 3770 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 3950 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 3950 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 4330 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 4330 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 4510 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 4510 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 4890 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 4890 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 5070 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 5070 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 5450 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 5450 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 5630 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 5630 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 6010 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 6010 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 6190 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 6190 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 6570 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 6570 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 6750 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 6750 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 7130 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 7130 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 7310 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 7310 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 7690 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 7690 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 7870 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 7870 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 8250 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 8250 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 8430 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 8430 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 8810 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 8810 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 8990 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 8990 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 9370 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 9370 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 9550 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 9550 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 9930 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 9930 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 10110 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 10110 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 10490 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 10490 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 10670 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 10670 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 11050 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 11050 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 11230 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 11230 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 11610 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 11610 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 11790 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 11790 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 12170 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 12170 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 12350 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 12350 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 12730 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 12730 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 12910 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 12910 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 13290 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 13290 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 13470 -120 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 13470 -150 0 0 {name=l_VDD lab=VDD}
C {devices/vdd.sym} 500 190 0 0 {name=l_VDD lab=VDD}
C {devices/gnd.sym} 240 120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 870 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 870 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1250 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1250 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1430 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1430 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1810 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1810 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1990 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1990 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 2370 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 2370 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 2550 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 2550 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 2930 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 2930 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3110 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3110 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3490 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3490 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3670 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3670 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4050 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4050 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4230 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4230 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4610 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4610 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4790 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4790 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5170 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5170 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5350 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5350 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5730 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5730 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5910 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5910 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6290 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6290 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6470 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6470 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6850 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6850 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7030 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7030 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7410 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7410 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7590 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7590 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7970 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7970 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 8150 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 8150 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 8530 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 8530 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 8710 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 8710 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9090 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9090 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9270 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9270 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9650 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9650 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9830 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9830 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10210 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10210 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10390 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10390 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10770 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10770 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10950 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10950 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 11330 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 11330 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 11510 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 11510 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 11890 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 11890 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12070 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12070 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12450 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12450 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12630 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12630 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 13010 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 13010 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 13190 -120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 13190 -150 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 370 250 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 110 380 0 0 {name=l_0 lab=GND}
C {devices/lab_pin.sym} 1100 -90 0 0 {name=l_LCA0 sig_type=std_logic lab=LCA0}
C {devices/lab_pin.sym} 1240 -90 0 0 {name=l_LCB0 sig_type=std_logic lab=LCB0}
C {devices/lab_pin.sym} 5000 -120 0 0 {name=l_B0 sig_type=std_logic lab=B0}
C {devices/lab_pin.sym} 5260 -120 0 0 {name=l_A0 sig_type=std_logic lab=A0}
C {devices/lab_pin.sym} 1660 -90 0 0 {name=l_LCA1 sig_type=std_logic lab=LCA1}
C {devices/lab_pin.sym} 1800 -90 0 0 {name=l_LCB1 sig_type=std_logic lab=LCB1}
C {devices/lab_pin.sym} 2220 -90 0 0 {name=l_LCA2 sig_type=std_logic lab=LCA2}
C {devices/lab_pin.sym} 2360 -90 0 0 {name=l_LCB2 sig_type=std_logic lab=LCB2}
C {devices/lab_pin.sym} 2780 -90 0 0 {name=l_LCA3 sig_type=std_logic lab=LCA3}
C {devices/lab_pin.sym} 2920 -90 0 0 {name=l_LCB3 sig_type=std_logic lab=LCB3}
C {devices/lab_pin.sym} 3340 -90 0 0 {name=l_LCA4 sig_type=std_logic lab=LCA4}
C {devices/lab_pin.sym} 3480 -90 0 0 {name=l_LCB4 sig_type=std_logic lab=LCB4}
C {devices/lab_pin.sym} 3900 -90 0 0 {name=l_LCA5 sig_type=std_logic lab=LCA5}
C {devices/lab_pin.sym} 4040 -90 0 0 {name=l_LCB5 sig_type=std_logic lab=LCB5}
C {devices/lab_pin.sym} 4460 -90 0 0 {name=l_LCA6 sig_type=std_logic lab=LCA6}
C {devices/lab_pin.sym} 4600 -90 0 0 {name=l_LCB6 sig_type=std_logic lab=LCB6}
C {devices/lab_pin.sym} 4900 -90 0 0 {name=l_LCA7 sig_type=std_logic lab=LCA7}
C {devices/lab_pin.sym} 5140 -90 0 0 {name=l_LCB7 sig_type=std_logic lab=LCB7}
C {devices/lab_pin.sym} 5580 -90 0 0 {name=l_LCA8 sig_type=std_logic lab=LCA8}
C {devices/lab_pin.sym} 5720 -90 0 0 {name=l_LCB8 sig_type=std_logic lab=LCB8}
C {devices/lab_pin.sym} 6140 -90 0 0 {name=l_LCA9 sig_type=std_logic lab=LCA9}
C {devices/lab_pin.sym} 6280 -90 0 0 {name=l_LCB9 sig_type=std_logic lab=LCB9}
C {devices/lab_pin.sym} 6700 -90 0 0 {name=l_LCA10 sig_type=std_logic lab=LCA10}
C {devices/lab_pin.sym} 6840 -90 0 0 {name=l_LCB10 sig_type=std_logic lab=LCB10}
C {devices/lab_pin.sym} 7260 -90 0 0 {name=l_LCA11 sig_type=std_logic lab=LCA11}
C {devices/lab_pin.sym} 7400 -90 0 0 {name=l_LCB11 sig_type=std_logic lab=LCB11}
C {devices/lab_pin.sym} 7820 -90 0 0 {name=l_LCA12 sig_type=std_logic lab=LCA12}
C {devices/lab_pin.sym} 7960 -90 0 0 {name=l_LCB12 sig_type=std_logic lab=LCB12}
C {devices/lab_pin.sym} 8380 -90 0 0 {name=l_LCA13 sig_type=std_logic lab=LCA13}
C {devices/lab_pin.sym} 8520 -90 0 0 {name=l_LCB13 sig_type=std_logic lab=LCB13}
C {devices/lab_pin.sym} 8940 -90 0 0 {name=l_LCA14 sig_type=std_logic lab=LCA14}
C {devices/lab_pin.sym} 9080 -90 0 0 {name=l_LCB14 sig_type=std_logic lab=LCB14}
C {devices/lab_pin.sym} 9500 -90 0 0 {name=l_LCA15 sig_type=std_logic lab=LCA15}
C {devices/lab_pin.sym} 9640 -90 0 0 {name=l_LCB15 sig_type=std_logic lab=LCB15}
C {devices/lab_pin.sym} 10060 -90 0 0 {name=l_LCA16 sig_type=std_logic lab=LCA16}
C {devices/lab_pin.sym} 10200 -90 0 0 {name=l_LCB16 sig_type=std_logic lab=LCB16}
C {devices/lab_pin.sym} 10620 -90 0 0 {name=l_LCA17 sig_type=std_logic lab=LCA17}
C {devices/lab_pin.sym} 10760 -90 0 0 {name=l_LCB17 sig_type=std_logic lab=LCB17}
C {devices/lab_pin.sym} 11180 -90 0 0 {name=l_LCA18 sig_type=std_logic lab=LCA18}
C {devices/lab_pin.sym} 11320 -90 0 0 {name=l_LCB18 sig_type=std_logic lab=LCB18}
C {devices/lab_pin.sym} 11740 -90 0 0 {name=l_LCA19 sig_type=std_logic lab=LCA19}
C {devices/lab_pin.sym} 11880 -90 0 0 {name=l_LCB19 sig_type=std_logic lab=LCB19}
C {devices/lab_pin.sym} 12300 -90 0 0 {name=l_LCA20 sig_type=std_logic lab=LCA20}
C {devices/lab_pin.sym} 12440 -90 0 0 {name=l_LCB20 sig_type=std_logic lab=LCB20}
C {devices/lab_pin.sym} 12860 -90 0 0 {name=l_LCA21 sig_type=std_logic lab=LCA21}
C {devices/lab_pin.sym} 13000 -90 0 0 {name=l_LCB21 sig_type=std_logic lab=LCB21}
C {devices/lab_pin.sym} 13420 -90 0 0 {name=l_LCA22 sig_type=std_logic lab=LCA22}
C {devices/lab_pin.sym} 13560 -90 0 0 {name=l_LCB22 sig_type=std_logic lab=LCB22}
C {devices/lab_pin.sym} 13710 -310 0 0 {name=l_LCA23 sig_type=std_logic lab=LCA23}
C {devices/lab_pin.sym} 13710 -250 0 0 {name=l_A24 sig_type=std_logic lab=A24}
C {devices/lab_pin.sym} 14040 -220 0 0 {name=l_A24 sig_type=std_logic lab=A24}
C {devices/lab_pin.sym} 5000 -60 0 0 {name=l_A24 sig_type=std_logic lab=A24}
C {devices/lab_pin.sym} 13930 -310 0 0 {name=l_LCB23 sig_type=std_logic lab=LCB23}
C {devices/lab_pin.sym} 5260 -60 0 0 {name=l_B24 sig_type=std_logic lab=B24}
C {devices/lab_pin.sym} 370 190 0 0 {name=l_VSLEW sig_type=std_logic lab=VSLEW}
C {devices/lab_pin.sym} 500 250 0 0 {name=l_VRAMP sig_type=std_logic lab=VRAMP}
C {devices/lab_pin.sym} 110 320 0 0 {name=l_VARACTOR_V sig_type=std_logic lab=VARACTOR_V}
C {devices/lab_pin.sym} 370 120 0 0 {name=l_VDD0 sig_type=std_logic lab=VDD0}
C {devices/lab_pin.sym} 110 120 0 0 {name=l_VDD0 sig_type=std_logic lab=VDD0}
C {devices/lab_pin.sym} 110 250 0 0 {name=l_VDD0 sig_type=std_logic lab=VDD0}
C {devices/lab_pin.sym} 110 60 0 0 {name=l_VDD0 sig_type=std_logic lab=VDD0}
