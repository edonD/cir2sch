** sch_path: data/sch/aicas_cutout1.sch
**.subckt aicas_cutout1
R1 1 1 1 m=1
R2 1 GND 1 m=1
**.ends
.GLOBAL GND
.end
