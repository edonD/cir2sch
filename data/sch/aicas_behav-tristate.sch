v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {74hct125.sym} 520 -300 0 0 {name=x1}
C {74hc126a.sym} 520 -120 0 0 {name=x2}
T {x1} 500 -280 0 0 0.25 0.25 {}
T {x2} 500 -100 0 0 0.25 0.25 {}
C {devices/lab_pin.sym} 490 -320 0 0 {name=l_1a sig_type=std_logic lab=1a}
C {devices/lab_pin.sym} 550 -320 0 0 {name=l_1y sig_type=std_logic lab=1y}
C {devices/lab_pin.sym} 490 -300 0 0 {name=l_oebar sig_type=std_logic lab=oebar}
C {devices/lab_pin.sym} 490 -140 0 0 {name=l_a1 sig_type=std_logic lab=a1}
C {devices/lab_pin.sym} 550 -140 0 0 {name=l_y1 sig_type=std_logic lab=y1}
C {devices/lab_pin.sym} 490 -120 0 0 {name=l_oe sig_type=std_logic lab=oe}
