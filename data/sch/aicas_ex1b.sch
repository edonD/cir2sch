** sch_path: data/sch/aicas_ex1b.sch
**.subckt aicas_ex1b
I1 GND GND -1mA
X1 GND GND sub1
R2 GND GND 4k m=1
X3 GND GND sub_in_lib
**.ends
.GLOBAL GND
.end
