v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {74ac283.sym} 520 -300 0 0 {name=X1}
T {X1} 500 -280 0 0 0.25 0.25 {}
C {devices/lab_pin.sym} 490 -360 0 0 {name=l_a0 sig_type=std_logic lab=a0}
C {devices/lab_pin.sym} 550 -360 0 0 {name=l_a1 sig_type=std_logic lab=a1}
C {devices/lab_pin.sym} 490 -340 0 0 {name=l_a2 sig_type=std_logic lab=a2}
C {devices/lab_pin.sym} 550 -340 0 0 {name=l_a3 sig_type=std_logic lab=a3}
C {devices/lab_pin.sym} 490 -320 0 0 {name=l_b0 sig_type=std_logic lab=b0}
C {devices/lab_pin.sym} 550 -320 0 0 {name=l_b1 sig_type=std_logic lab=b1}
C {devices/lab_pin.sym} 490 -300 0 0 {name=l_b2 sig_type=std_logic lab=b2}
C {devices/lab_pin.sym} 550 -300 0 0 {name=l_b3 sig_type=std_logic lab=b3}
C {devices/lab_pin.sym} 490 -280 0 0 {name=l_cin sig_type=std_logic lab=cin}
C {devices/lab_pin.sym} 550 -280 0 0 {name=l_cout sig_type=std_logic lab=cout}
C {devices/lab_pin.sym} 490 -260 0 0 {name=l_s0 sig_type=std_logic lab=s0}
C {devices/lab_pin.sym} 550 -260 0 0 {name=l_s1 sig_type=std_logic lab=s1}
C {devices/lab_pin.sym} 490 -240 0 0 {name=l_s2 sig_type=std_logic lab=s2}
C {devices/lab_pin.sym} 550 -240 0 0 {name=l_s3 sig_type=std_logic lab=s3}
