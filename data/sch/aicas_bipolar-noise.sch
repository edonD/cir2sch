v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/res.sym} 440 -280 0 0 {name=r1
value=r=1k}
C {devices/res.sym} 660 -280 0 0 {name=r2
value=r=1k}
C {devices/lab_pin.sym} 440 -310 0 0 {name=l_1 sig_type=std_logic lab=1}
C {devices/lab_pin.sym} 440 -250 0 0 {name=l_2 sig_type=std_logic lab=2}
C {devices/lab_pin.sym} 660 -310 0 0 {name=l_3 sig_type=std_logic lab=3}
C {devices/lab_pin.sym} 660 -250 0 0 {name=l_4 sig_type=std_logic lab=4}
