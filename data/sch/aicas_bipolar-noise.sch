** sch_path: data/sch/aicas_bipolar-noise.sch
**.subckt aicas_bipolar-noise
v1 2 GND 3
r1 2 2 r=1k m=1
r2 3 net1 r=1k m=1
vin net1 GND 1
**.ends
.GLOBAL GND
.end
