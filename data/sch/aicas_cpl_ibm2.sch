v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/res.sym} 1100 -280 0 0 {name=R1
value=50}
C {devices/res.sym} 440 -400 0 0 {name=R2
value=10}
C {devices/res.sym} 660 -400 0 0 {name=R3
value=100}
C {devices/res.sym} 880 -400 0 0 {name=R4
value=100}
C {devices/lab_pin.sym} 1100 -310 0 0 {name=l_IN sig_type=std_logic lab=IN}
C {devices/gnd.sym} 440 -370 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 660 -370 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 880 -370 0 0 {name=l_0 lab=GND}
C {devices/lab_pin.sym} 1100 -250 0 0 {name=l_V1 sig_type=std_logic lab=V1}
C {devices/lab_pin.sym} 440 -430 0 0 {name=l_V2 sig_type=std_logic lab=V2}
C {devices/lab_pin.sym} 660 -430 0 0 {name=l_V3 sig_type=std_logic lab=V3}
C {devices/lab_pin.sym} 880 -430 0 0 {name=l_V4 sig_type=std_logic lab=V4}
