v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {counter, latch DAC} 0 -820 0 0 0.5 0.5 {}
