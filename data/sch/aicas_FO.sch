** sch_path: data/sch/aicas_FO.sch
**.subckt aicas_FO
VBIC Output Test 3
V1 V1_P V1_P 0.0
VB V1_P GND 0.5
VC Q1_C GND 0.0
**.ends
.GLOBAL GND
.end
