** sch_path: data/sch/aicas_bjtnoise.sch
**.subckt aicas_bjtnoise
ccouple 1 GND 1 m=1
ibias GND GND 100uA
rload 4 3 1k m=1
**.ends
.GLOBAL GND
.end
