v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {BSIMSOI (PD) example} 170 -270 0 0 0.5 0.5 {}
C {devices/nmos4.sym} 220 -150 0 0 {name=m1
w=5u
l=0.18u
model=n1}
C {devices/lab_pin.sym} 240 -180 0 0 {name=l_d sig_type=std_logic lab=d}
C {devices/lab_pin.sym} 200 -150 0 0 {name=l_g sig_type=std_logic lab=g}
C {devices/lab_pin.sym} 240 -150 0 0 {name=l_e sig_type=std_logic lab=e}
C {devices/lab_pin.sym} 240 -120 0 0 {name=l_s sig_type=std_logic lab=s}
