v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/res.sym} 440 -400 0 0 {name=R1
value=100}
C {devices/res.sym} 660 -280 0 0 {name=Rtj
value=100}
C {devices/lab_pin.sym} 660 -250 0 0 {name=l_tamb sig_type=std_logic lab=tamb}
C {devices/gnd.sym} 440 -370 0 0 {name=l_0 lab=GND}
C {devices/lab_pin.sym} 440 -430 0 0 {name=l_1 sig_type=std_logic lab=1}
C {devices/lab_pin.sym} 660 -310 0 0 {name=l_tj sig_type=std_logic lab=tj}
