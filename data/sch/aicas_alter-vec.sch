v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {check alter @v1[pulse] = [ 1 2 3 4 5 6 ]} 0 -820 0 0 0.5 0.5 {}
