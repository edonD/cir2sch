v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {* Unsupported fifo on Windows VisualC} 390 -395 0 0 0.35 0.35 {}
C {devices/capa.sym} 440 -280 0 0 {name=checks.cir
value=handling.}
C {devices/lab_pin.sym} 440 -310 0 0 {name=l_test sig_type=std_logic lab=test}
C {devices/lab_pin.sym} 440 -250 0 0 {name=l_error sig_type=std_logic lab=error}
