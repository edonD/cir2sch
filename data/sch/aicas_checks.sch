v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {* Unsupported fifo on Windows VisualC} 390 -395 0 0 0.35 0.35 {}
C {devices/capa.sym} 440 -280 0 0 {name=checks.cir
value=handling.}
C {devices/vsource.sym} 440 -130 0 0 {name=v1
value=1.0}
C {devices/vsource.sym} 570 -130 0 0 {name=v2
value=0.0}
C {devices/lab_pin.sym} 440 -310 0 0 {name=l_test sig_type=std_logic lab=test}
C {devices/lab_pin.sym} 440 -250 0 0 {name=l_error sig_type=std_logic lab=error}
C {devices/lab_pin.sym} 440 -160 0 0 {name=l_1 sig_type=std_logic lab=1}
C {devices/gnd.sym} 440 -100 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 570 -100 0 0 {name=l_0 lab=GND}
C {devices/lab_pin.sym} 570 -160 0 0 {name=l_2 sig_type=std_logic lab=2}
