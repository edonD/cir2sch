** sch_path: data/sch/aicas_diffpair.sch
**.subckt aicas_diffpair
rs1 11 2 1k m=1
rs2 3 1 1k m=1
rc1 4 net1 10k m=1
rc2 5 net1 10k m=1
rbias 7 net1 20k m=1
**.ends
.end
