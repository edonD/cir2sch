v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {74f524.sym} 520 -300 0 0 {name=X86}
T {X86} 500 -280 0 0 0.25 0.25 {}
C {devices/lab_pin.sym} 490 -380 0 0 {name=l_i_s0 sig_type=std_logic lab=i_s0}
C {devices/lab_pin.sym} 550 -380 0 0 {name=l_i_s1 sig_type=std_logic lab=i_s1}
C {devices/lab_pin.sym} 490 -360 0 0 {name=l_i_sebar sig_type=std_logic lab=i_sebar}
C {devices/lab_pin.sym} 550 -360 0 0 {name=l_csi sig_type=std_logic lab=csi}
C {devices/lab_pin.sym} 490 -340 0 0 {name=l_io0 sig_type=std_logic lab=io0}
C {devices/lab_pin.sym} 550 -340 0 0 {name=l_io1 sig_type=std_logic lab=io1}
C {devices/lab_pin.sym} 490 -320 0 0 {name=l_io2 sig_type=std_logic lab=io2}
C {devices/lab_pin.sym} 550 -320 0 0 {name=l_io3 sig_type=std_logic lab=io3}
C {devices/lab_pin.sym} 490 -300 0 0 {name=l_io4 sig_type=std_logic lab=io4}
C {devices/lab_pin.sym} 550 -300 0 0 {name=l_io5 sig_type=std_logic lab=io5}
C {devices/lab_pin.sym} 490 -280 0 0 {name=l_io6 sig_type=std_logic lab=io6}
C {devices/lab_pin.sym} 550 -280 0 0 {name=l_io7 sig_type=std_logic lab=io7}
C {devices/lab_pin.sym} 490 -260 0 0 {name=l_cp sig_type=std_logic lab=cp}
C {devices/lab_pin.sym} 550 -260 0 0 {name=l_i_m sig_type=std_logic lab=i_m}
C {devices/lab_pin.sym} 490 -240 0 0 {name=l_o_cso sig_type=std_logic lab=o_cso}
C {devices/lab_pin.sym} 550 -240 0 0 {name=l_o_eq sig_type=std_logic lab=o_eq}
C {devices/lab_pin.sym} 490 -220 0 0 {name=l_o_gt sig_type=std_logic lab=o_gt}
C {devices/lab_pin.sym} 550 -220 0 0 {name=l_o_lt sig_type=std_logic lab=o_lt}
