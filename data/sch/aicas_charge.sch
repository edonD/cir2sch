** sch_path: data/sch/aicas_charge.sch
**.subckt aicas_charge
VBB GND GND 0V
RD 6 2 10K m=1
M1 5 4 3 GND MMOD w=100UM l=0.18u m=1
C2 1 GND 10PF m=1
**.ends
.GLOBAL GND
.end
