** sch_path: data/sch/aicas_CEamp.sch
**.subckt aicas_CEamp
Rc 2 2 1k m=1
Rb 2 net1 200k m=1
I1 GND net1 AC
Cshunt 4 GND .1u m=1
**.ends
.GLOBAL GND
.end
