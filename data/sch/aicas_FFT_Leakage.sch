v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {Create_Signal} 0 -815 0 0 0.35 0.35 {}
