v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/res.sym} 440 -280 0 0 {name=RL
value=1.0K}
C {devices/lab_pin.sym} 440 -250 0 0 {name=l_2 sig_type=std_logic lab=2}
C {devices/lab_pin.sym} 440 -310 0 0 {name=l_1 sig_type=std_logic lab=1}
