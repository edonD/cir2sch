** sch_path: data/sch/aicas_dbridge.sch
**.subckt aicas_dbridge
VLINE 3 4 0.0V
VGRND net1 GND 0.0V
RL 1 net1 1.0K m=1
**.ends
.GLOBAL GND
.end
