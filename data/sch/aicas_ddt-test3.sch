** sch_path: data/sch/aicas_ddt-test3.sch
**.subckt aicas_ddt-test3
R1 1 1 1k m=1
C1 1 GND 1u m=1
**.ends
.GLOBAL GND
.end
