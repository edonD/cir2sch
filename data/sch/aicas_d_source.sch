v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/capa.sym} 440 -280 0 0 {name=Code
value=d_source}
C {devices/vsource.sym} 440 -130 0 0 {name=vdummy}
C {devices/lab_pin.sym} 440 -310 0 0 {name=l_Model sig_type=std_logic lab=Model}
C {devices/lab_pin.sym} 440 -250 0 0 {name=l_Test: sig_type=std_logic lab=Test:}
C {devices/lab_pin.sym} 440 -160 0 0 {name=l_dummy sig_type=std_logic lab=dummy}
C {devices/gnd.sym} 440 -100 0 0 {name=l_0 lab=GND}
