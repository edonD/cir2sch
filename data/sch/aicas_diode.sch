v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {1. An operating point at 0.7v forward bias.} 0 -865 0 0 0.35 0.35 {}
T {2. An ac analysis at 0.7v forward bias.} 0 -840 0 0 0.35 0.35 {}
T {3. The forward and reverse bias characteristics from -3v to 2v.} 0 -815 0 0 0.35 0.35 {}
