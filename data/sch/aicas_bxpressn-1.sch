v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {'bxpressn-1' check b parser} 250 30 0 0 0.5 0.5 {}
C {devices/vsource.sym} 300 150 0 0 {name=v1001_g
value='3'}
C {devices/vsource.sym} 430 150 0 0 {name=v1002_g
value='3'}
C {devices/vsource.sym} 560 150 0 0 {name=v1003_g
value='7'}
C {devices/vsource.sym} 690 150 0 0 {name=v1004_g
value='102'}
C {devices/vsource.sym} 300 280 0 0 {name=v1005_g
value='107'}
C {devices/vsource.sym} 430 280 0 0 {name=v1006_g
value='-1.1'}
C {devices/vsource.sym} 560 280 0 0 {name=v1007_g
value='2'}
C {devices/vsource.sym} 690 280 0 0 {name=v1008_g
value='4.5'}
C {devices/vsource.sym} 300 410 0 0 {name=v1009_g
value='0'}
C {devices/vsource.sym} 430 410 0 0 {name=v1010_g
value='0'}
C {devices/vsource.sym} 560 410 0 0 {name=v1011_g
value='0'}
C {devices/vsource.sym} 690 410 0 0 {name=v1012_g
value='1'}
C {devices/vsource.sym} 300 540 0 0 {name=v1013_g
value='1'}
C {devices/vsource.sym} 430 540 0 0 {name=v1014_g
value='0'}
C {devices/vsource.sym} 560 540 0 0 {name=v1015_g
value='1'}
C {devices/vsource.sym} 690 540 0 0 {name=v1016_g
value='1'}
C {devices/vsource.sym} 300 670 0 0 {name=v1017_g
value='1'}
C {devices/vsource.sym} 430 670 0 0 {name=v1018_g
value='1'}
C {devices/vsource.sym} 560 670 0 0 {name=v1019_g
value='0'}
C {devices/vsource.sym} 690 670 0 0 {name=v1020_g
value='0'}
C {devices/vsource.sym} 300 800 0 0 {name=v1021_g
value='1'}
C {devices/vsource.sym} 430 800 0 0 {name=v1022_g
value='0'}
C {devices/vsource.sym} 560 800 0 0 {name=v1023_g
value='0'}
C {devices/vsource.sym} 690 800 0 0 {name=v1024_g
value='0'}
C {devices/vsource.sym} 300 930 0 0 {name=v1025_g
value='1'}
C {devices/vsource.sym} 430 930 0 0 {name=v1026_g
value='0'}
C {devices/vsource.sym} 560 930 0 0 {name=v1027_g
value='1'}
C {devices/vsource.sym} 690 930 0 0 {name=v1028_g
value='0'}
C {devices/vsource.sym} 300 1060 0 0 {name=v1029_g
value='1'}
C {devices/vsource.sym} 430 1060 0 0 {name=v1030_g
value='0'}
C {devices/vsource.sym} 560 1060 0 0 {name=v1031_g
value='1'}
C {devices/vsource.sym} 690 1060 0 0 {name=v1032_g
value='1'}
C {devices/vsource.sym} 300 1190 0 0 {name=v1033_g
value='0'}
C {devices/vsource.sym} 430 1190 0 0 {name=v1034_g
value='0'}
C {devices/vsource.sym} 560 1190 0 0 {name=v1035_g
value='1'}
C {devices/vsource.sym} 690 1190 0 0 {name=v1036_g
value='1'}
C {devices/vsource.sym} 300 1320 0 0 {name=v1037_g
value='1'}
C {devices/vsource.sym} 430 1320 0 0 {name=v1038_g
value='0'}
C {devices/vsource.sym} 560 1320 0 0 {name=v1039_g
value='8'}
C {devices/vsource.sym} 690 1320 0 0 {name=v1040_g
value='8'}
C {devices/vsource.sym} 300 1450 0 0 {name=v1041_g
value='8'}
C {devices/vsource.sym} 430 1450 0 0 {name=v1042_g
value='8'}
C {devices/vsource.sym} 560 1450 0 0 {name=v1043_g
value='42'}
C {devices/vsource.sym} 690 1450 0 0 {name=v1044_g
value='42'}
C {devices/vsource.sym} 300 1580 0 0 {name=v1045_g
value='43'}
C {devices/vsource.sym} 430 1580 0 0 {name=v1046_g
value='42'}
C {devices/vsource.sym} 560 1580 0 0 {name=v1047_g
value='42'}
C {devices/vsource.sym} 690 1580 0 0 {name=v1048_g
value='41'}
C {devices/vsource.sym} 300 1710 0 0 {name=v1049_g
value='40'}
C {devices/vsource.sym} 430 1710 0 0 {name=v1050_g
value='0.2'}
C {devices/vsource.sym} 560 1710 0 0 {name=v1051_g
value='5'}
C {devices/vsource.sym} 690 1710 0 0 {name=v1052_g
value='42'}
C {devices/vsource.sym} 300 1840 0 0 {name=v1053_g
value='0.29552020666133955'}
C {devices/vsource.sym} 430 1840 0 0 {name=v1054_g
value='0.955336489125606'}
C {devices/vsource.sym} 560 1840 0 0 {name=v1055_g
value='0.30933624960962325'}
C {devices/vsource.sym} 690 1840 0 0 {name=v1056_g
value='0.3046926540153975'}
C {devices/vsource.sym} 300 1970 0 0 {name=v1057_g
value='1.266103672779499'}
C {devices/vsource.sym} 430 1970 0 0 {name=v1058_g
value='0.29145679447786704'}
C {devices/vsource.sym} 560 1970 0 0 {name=v1059_g
value='0.29145679447786704'}
C {devices/vsource.sym} 690 1970 0 0 {name=v1060_g
value='0.3045202934471426'}
C {devices/vsource.sym} 300 2100 0 0 {name=v1061_g
value='1.0453385141288605'}
C {devices/vsource.sym} 430 2100 0 0 {name=v1062_g
value='0.2913126124515909'}
C {devices/vsource.sym} 560 2100 0 0 {name=v1063_g
value='0.2956730475634223'}
C {devices/vsource.sym} 690 2100 0 0 {name=v1064_g
value='0.7564329108569595'}
C {devices/vsource.sym} 300 2230 0 0 {name=v1065_g
value='0.3095196042031116'}
C {devices/vsource.sym} 430 2230 0 0 {name=v1066_g
value='7.38905609893065'}
C {devices/vsource.sym} 560 2230 0 0 {name=v1067_g
value='0.1353352832366127'}
C {devices/vsource.sym} 690 2230 0 0 {name=v1068_g
value='0.6931471805599453'}
C {devices/vsource.sym} 300 2360 0 0 {name=v1069_g
value='-0.6931471805599453'}
C {devices/vsource.sym} 430 2360 0 0 {name=v1070_g
value='0.6931471805599453'}
C {devices/vsource.sym} 560 2360 0 0 {name=v1071_g
value='-0.6931471805599453'}
C {devices/vsource.sym} 690 2360 0 0 {name=v1072_g
value='1.4142135623730951'}
C {devices/vsource.sym} 300 2490 0 0 {name=v1073_g
value='4.0'}
C {devices/vsource.sym} 430 2490 0 0 {name=v1074_g
value='2'}
C {devices/vsource.sym} 560 2490 0 0 {name=v1075_g
value='2'}
C {devices/vsource.sym} 690 2490 0 0 {name=v1076_g
value='1'}
C {devices/vsource.sym} 300 2620 0 0 {name=v1077_g
value='0'}
C {devices/vsource.sym} 430 2620 0 0 {name=v1078_g
value='-1'}
C {devices/vsource.sym} 560 2620 0 0 {name=v1079_g
value='2'}
C {devices/vsource.sym} 690 2620 0 0 {name=v1080_g
value='1'}
C {devices/vsource.sym} 300 2750 0 0 {name=v1081_g
value='0'}
C {devices/vsource.sym} 430 2750 0 0 {name=v1082_g
value='-1'}
C {devices/vsource.sym} 560 2750 0 0 {name=v1083_g
value='-2'}
C {devices/vsource.sym} 690 2750 0 0 {name=v1084_g
value='3'}
C {devices/vsource.sym} 300 2880 0 0 {name=v1085_g
value='2'}
C {devices/vsource.sym} 430 2880 0 0 {name=v1086_g
value='2'}
C {devices/vsource.sym} 560 2880 0 0 {name=v1087_g
value='2'}
C {devices/vsource.sym} 690 2880 0 0 {name=v1088_g
value='2'}
C {devices/vsource.sym} 300 3010 0 0 {name=v1089_g
value='1'}
C {devices/vsource.sym} 430 3010 0 0 {name=v1090_g
value='1'}
C {devices/vsource.sym} 560 3010 0 0 {name=v1091_g
value='0'}
C {devices/vsource.sym} 690 3010 0 0 {name=v1092_g
value='0'}
C {devices/vsource.sym} 300 3140 0 0 {name=v1093_g
value='0'}
C {devices/vsource.sym} 430 3140 0 0 {name=v1094_g
value='0'}
C {devices/vsource.sym} 560 3140 0 0 {name=v1095_g
value='0'}
C {devices/vsource.sym} 690 3140 0 0 {name=v1096_g
value='-1'}
C {devices/vsource.sym} 300 3270 0 0 {name=v1097_g
value='-1'}
C {devices/vsource.sym} 430 3270 0 0 {name=v1098_g
value='-2'}
C {devices/vsource.sym} 560 3270 0 0 {name=v1099_g
value='-2'}
C {devices/vsource.sym} 690 3270 0 0 {name=v1100_g
value='-2'}
C {devices/vsource.sym} 300 3400 0 0 {name=v1101_g
value='-2'}
C {devices/vsource.sym} 430 3400 0 0 {name=v1102_g
value='-3'}
C {devices/vsource.sym} 560 3400 0 0 {name=v1103_g
value='2'}
C {devices/vsource.sym} 690 3400 0 0 {name=v1104_g
value='1'}
C {devices/vsource.sym} 300 3530 0 0 {name=v1105_g
value='0'}
C {devices/vsource.sym} 430 3530 0 0 {name=v1106_g
value='-2'}
C {devices/vsource.sym} 560 3530 0 0 {name=v1107_g
value='-3'}
C {devices/vsource.sym} 690 3530 0 0 {name=v1108_g
value='3'}
C {devices/vsource.sym} 300 3660 0 0 {name=v1109_g
value='2'}
C {devices/vsource.sym} 430 3660 0 0 {name=v1110_g
value='0'}
C {devices/vsource.sym} 560 3660 0 0 {name=v1111_g
value='-1'}
C {devices/vsource.sym} 690 3660 0 0 {name=v1112_g
value='-2'}
C {devices/vsource.sym} 300 3790 0 0 {name=v1113_g
value='1.1'}
C {devices/vsource.sym} 430 3790 0 0 {name=v1114_g
value='1.1'}
C {devices/vsource.sym} 560 3790 0 0 {name=v1115_g
value='2.1'}
C {devices/vsource.sym} 690 3790 0 0 {name=v1116_g
value='2.1'}
C {devices/vsource.sym} 300 3920 0 0 {name=v1117_g
value='1.0'}
C {devices/vsource.sym} 430 3920 0 0 {name=v1118_g
value='-0.3010299956639812'}
C {devices/vsource.sym} 560 3920 0 0 {name=v1119_g
value='1'}
C {devices/vsource.sym} 690 3920 0 0 {name=v1120_g
value='0.5'}
C {devices/vsource.sym} 300 4050 0 0 {name=v1121_g
value='0'}
C {devices/vsource.sym} 430 4050 0 0 {name=v1122_g
value='0.25'}
C {devices/vsource.sym} 560 4050 0 0 {name=v1123_g
value='0'}
C {devices/vsource.sym} 690 4050 0 0 {name=v1124_g
value='0'}
C {devices/vsource.sym} 300 4180 0 0 {name=v1125_g
value='-42'}
C {devices/vsource.sym} 430 4180 0 0 {name=v1126_g
value='0'}
C {devices/vsource.sym} 560 4180 0 0 {name=v1127_g
value='0'}
C {devices/vsource.sym} 690 4180 0 0 {name=v1128_g
value='0.25'}
C {devices/vsource.sym} 300 4310 0 0 {name=v1129_g
value='0.75'}
C {devices/vsource.sym} 430 4310 0 0 {name=v1130_g
value='1'}
C {devices/vsource.sym} 560 4310 0 0 {name=v1131_g
value='1'}
C {devices/vsource.sym} 690 4310 0 0 {name=v1132_g
value='-98'}
C {devices/vsource.sym} 300 4440 0 0 {name=v1133_g
value='2.5'}
C {devices/vsource.sym} 430 4440 0 0 {name=v1134_g
value='6'}
C {devices/vsource.sym} 560 4440 0 0 {name=v1135_g
value='97'}
C {devices/vsource.sym} 690 4440 0 0 {name=v1136_g
value='0'}
C {devices/vsource.sym} 300 4570 0 0 {name=v1137_g
value='1'}
C {devices/vsource.sym} 430 4570 0 0 {name=v1138_g
value='0'}
C {devices/vsource.sym} 560 4570 0 0 {name=v1139_g
value='1'}
C {devices/vsource.sym} 690 4570 0 0 {name=v1140_g
value='0'}
C {devices/vsource.sym} 300 4700 0 0 {name=v1141_g
value='1'}
C {devices/vsource.sym} 430 4700 0 0 {name=v1142_g
value='0'}
C {devices/vsource.sym} 560 4700 0 0 {name=v1143_g
value='0'}
C {devices/vsource.sym} 690 4700 0 0 {name=v1144_g
value='1'}
C {devices/vsource.sym} 300 4830 0 0 {name=v1145_g
value='1'}
C {devices/vsource.sym} 430 4830 0 0 {name=v1146_g
value='0'}
C {devices/vsource.sym} 560 4830 0 0 {name=v1147_g
value='0'}
C {devices/vsource.sym} 690 4830 0 0 {name=v1148_g
value='0'}
C {devices/vsource.sym} 300 4960 0 0 {name=v1149_g
value='1'}
C {devices/vsource.sym} 430 4960 0 0 {name=v1150_g
value='1'}
C {devices/vsource.sym} 560 4960 0 0 {name=v1151_g
value='1'}
C {devices/vsource.sym} 690 4960 0 0 {name=v1152_g
value='1'}
C {devices/vsource.sym} 300 5090 0 0 {name=v1153_g
value='0'}
C {devices/vsource.sym} 430 5090 0 0 {name=vaux1
value=42.0}
C {devices/vsource.sym} 560 5090 0 0 {name=v1154_g
value='42.0'}
C {devices/vsource.sym} 690 5090 0 0 {name=v1155_g
value='42.0'}
C {devices/lab_pin.sym} 300 120 0 0 {name=l_n1001_g sig_type=std_logic lab=n1001_g}
C {devices/gnd.sym} 300 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 310 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 310 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 310 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 310 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 440 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 440 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 440 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 440 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 570 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 570 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 570 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 570 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 700 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 700 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 700 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 700 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 830 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 830 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 830 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 830 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 960 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 960 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 960 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 960 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 1090 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 1090 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 1090 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 1090 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 1220 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 1220 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 1220 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 1220 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 1350 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 1350 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 1350 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 1350 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 1480 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 1480 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 1480 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 1480 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 1610 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 1610 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 1610 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 1610 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 1740 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 1740 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 1740 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 1740 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 1870 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 1870 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 1870 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 1870 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 2000 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 2000 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 2000 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 2000 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 2130 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 2130 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 2130 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 2130 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 2260 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 2260 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 2260 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 2260 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 2390 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 2390 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 2390 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 2390 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 2520 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 2520 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 2520 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 2520 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 2650 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 2650 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 2650 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 2650 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 2780 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 2780 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 2780 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 2780 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 2910 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 2910 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 2910 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 2910 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 3040 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 3040 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 3040 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 3040 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 3170 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 3170 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 3170 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 3170 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 3300 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 3300 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 3300 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 3300 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 3430 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 3430 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 3430 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 3430 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 3560 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 3560 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 3560 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 3560 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 3690 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 3690 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 3690 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 3690 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 3820 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 3820 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 3820 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 3820 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 3950 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 3950 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 3950 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 3950 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 4080 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 4080 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 4080 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 4080 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 4210 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 4210 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 4210 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 4210 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 4340 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 4340 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 4340 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 4340 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 4470 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 4470 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 4470 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 4470 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 4600 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 4600 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 4600 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 4600 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 4730 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 4730 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 4730 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 4730 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 4860 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 4860 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 4860 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 4860 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 4990 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 4990 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 4990 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 4990 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 300 5120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 5120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 5120 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 5120 0 0 {name=l_0 lab=GND}
C {devices/lab_pin.sym} 430 120 0 0 {name=l_n1002_g sig_type=std_logic lab=n1002_g}
C {devices/lab_pin.sym} 560 120 0 0 {name=l_n1003_g sig_type=std_logic lab=n1003_g}
C {devices/lab_pin.sym} 690 120 0 0 {name=l_n1004_g sig_type=std_logic lab=n1004_g}
C {devices/lab_pin.sym} 300 250 0 0 {name=l_n1005_g sig_type=std_logic lab=n1005_g}
C {devices/lab_pin.sym} 430 250 0 0 {name=l_n1006_g sig_type=std_logic lab=n1006_g}
C {devices/lab_pin.sym} 560 250 0 0 {name=l_n1007_g sig_type=std_logic lab=n1007_g}
C {devices/lab_pin.sym} 690 250 0 0 {name=l_n1008_g sig_type=std_logic lab=n1008_g}
C {devices/lab_pin.sym} 300 380 0 0 {name=l_n1009_g sig_type=std_logic lab=n1009_g}
C {devices/lab_pin.sym} 430 380 0 0 {name=l_n1010_g sig_type=std_logic lab=n1010_g}
C {devices/lab_pin.sym} 560 380 0 0 {name=l_n1011_g sig_type=std_logic lab=n1011_g}
C {devices/lab_pin.sym} 690 380 0 0 {name=l_n1012_g sig_type=std_logic lab=n1012_g}
C {devices/lab_pin.sym} 300 510 0 0 {name=l_n1013_g sig_type=std_logic lab=n1013_g}
C {devices/lab_pin.sym} 430 510 0 0 {name=l_n1014_g sig_type=std_logic lab=n1014_g}
C {devices/lab_pin.sym} 560 510 0 0 {name=l_n1015_g sig_type=std_logic lab=n1015_g}
C {devices/lab_pin.sym} 690 510 0 0 {name=l_n1016_g sig_type=std_logic lab=n1016_g}
C {devices/lab_pin.sym} 300 640 0 0 {name=l_n1017_g sig_type=std_logic lab=n1017_g}
C {devices/lab_pin.sym} 430 640 0 0 {name=l_n1018_g sig_type=std_logic lab=n1018_g}
C {devices/lab_pin.sym} 560 640 0 0 {name=l_n1019_g sig_type=std_logic lab=n1019_g}
C {devices/lab_pin.sym} 690 640 0 0 {name=l_n1020_g sig_type=std_logic lab=n1020_g}
C {devices/lab_pin.sym} 300 770 0 0 {name=l_n1021_g sig_type=std_logic lab=n1021_g}
C {devices/lab_pin.sym} 430 770 0 0 {name=l_n1022_g sig_type=std_logic lab=n1022_g}
C {devices/lab_pin.sym} 560 770 0 0 {name=l_n1023_g sig_type=std_logic lab=n1023_g}
C {devices/lab_pin.sym} 690 770 0 0 {name=l_n1024_g sig_type=std_logic lab=n1024_g}
C {devices/lab_pin.sym} 300 900 0 0 {name=l_n1025_g sig_type=std_logic lab=n1025_g}
C {devices/lab_pin.sym} 430 900 0 0 {name=l_n1026_g sig_type=std_logic lab=n1026_g}
C {devices/lab_pin.sym} 560 900 0 0 {name=l_n1027_g sig_type=std_logic lab=n1027_g}
C {devices/lab_pin.sym} 690 900 0 0 {name=l_n1028_g sig_type=std_logic lab=n1028_g}
C {devices/lab_pin.sym} 300 1030 0 0 {name=l_n1029_g sig_type=std_logic lab=n1029_g}
C {devices/lab_pin.sym} 430 1030 0 0 {name=l_n1030_g sig_type=std_logic lab=n1030_g}
C {devices/lab_pin.sym} 560 1030 0 0 {name=l_n1031_g sig_type=std_logic lab=n1031_g}
C {devices/lab_pin.sym} 690 1030 0 0 {name=l_n1032_g sig_type=std_logic lab=n1032_g}
C {devices/lab_pin.sym} 300 1160 0 0 {name=l_n1033_g sig_type=std_logic lab=n1033_g}
C {devices/lab_pin.sym} 430 1160 0 0 {name=l_n1034_g sig_type=std_logic lab=n1034_g}
C {devices/lab_pin.sym} 560 1160 0 0 {name=l_n1035_g sig_type=std_logic lab=n1035_g}
C {devices/lab_pin.sym} 690 1160 0 0 {name=l_n1036_g sig_type=std_logic lab=n1036_g}
C {devices/lab_pin.sym} 300 1290 0 0 {name=l_n1037_g sig_type=std_logic lab=n1037_g}
C {devices/lab_pin.sym} 430 1290 0 0 {name=l_n1038_g sig_type=std_logic lab=n1038_g}
C {devices/lab_pin.sym} 560 1290 0 0 {name=l_n1039_g sig_type=std_logic lab=n1039_g}
C {devices/lab_pin.sym} 690 1290 0 0 {name=l_n1040_g sig_type=std_logic lab=n1040_g}
C {devices/lab_pin.sym} 300 1420 0 0 {name=l_n1041_g sig_type=std_logic lab=n1041_g}
C {devices/lab_pin.sym} 430 1420 0 0 {name=l_n1042_g sig_type=std_logic lab=n1042_g}
C {devices/lab_pin.sym} 560 1420 0 0 {name=l_n1043_g sig_type=std_logic lab=n1043_g}
C {devices/lab_pin.sym} 690 1420 0 0 {name=l_n1044_g sig_type=std_logic lab=n1044_g}
C {devices/lab_pin.sym} 300 1550 0 0 {name=l_n1045_g sig_type=std_logic lab=n1045_g}
C {devices/lab_pin.sym} 430 1550 0 0 {name=l_n1046_g sig_type=std_logic lab=n1046_g}
C {devices/lab_pin.sym} 560 1550 0 0 {name=l_n1047_g sig_type=std_logic lab=n1047_g}
C {devices/lab_pin.sym} 690 1550 0 0 {name=l_n1048_g sig_type=std_logic lab=n1048_g}
C {devices/lab_pin.sym} 300 1680 0 0 {name=l_n1049_g sig_type=std_logic lab=n1049_g}
C {devices/lab_pin.sym} 430 1680 0 0 {name=l_n1050_g sig_type=std_logic lab=n1050_g}
C {devices/lab_pin.sym} 560 1680 0 0 {name=l_n1051_g sig_type=std_logic lab=n1051_g}
C {devices/lab_pin.sym} 690 1680 0 0 {name=l_n1052_g sig_type=std_logic lab=n1052_g}
C {devices/lab_pin.sym} 300 1810 0 0 {name=l_n1053_g sig_type=std_logic lab=n1053_g}
C {devices/lab_pin.sym} 430 1810 0 0 {name=l_n1054_g sig_type=std_logic lab=n1054_g}
C {devices/lab_pin.sym} 560 1810 0 0 {name=l_n1055_g sig_type=std_logic lab=n1055_g}
C {devices/lab_pin.sym} 690 1810 0 0 {name=l_n1056_g sig_type=std_logic lab=n1056_g}
C {devices/lab_pin.sym} 300 1940 0 0 {name=l_n1057_g sig_type=std_logic lab=n1057_g}
C {devices/lab_pin.sym} 430 1940 0 0 {name=l_n1058_g sig_type=std_logic lab=n1058_g}
C {devices/lab_pin.sym} 560 1940 0 0 {name=l_n1059_g sig_type=std_logic lab=n1059_g}
C {devices/lab_pin.sym} 690 1940 0 0 {name=l_n1060_g sig_type=std_logic lab=n1060_g}
C {devices/lab_pin.sym} 300 2070 0 0 {name=l_n1061_g sig_type=std_logic lab=n1061_g}
C {devices/lab_pin.sym} 430 2070 0 0 {name=l_n1062_g sig_type=std_logic lab=n1062_g}
C {devices/lab_pin.sym} 560 2070 0 0 {name=l_n1063_g sig_type=std_logic lab=n1063_g}
C {devices/lab_pin.sym} 690 2070 0 0 {name=l_n1064_g sig_type=std_logic lab=n1064_g}
C {devices/lab_pin.sym} 300 2200 0 0 {name=l_n1065_g sig_type=std_logic lab=n1065_g}
C {devices/lab_pin.sym} 430 2200 0 0 {name=l_n1066_g sig_type=std_logic lab=n1066_g}
C {devices/lab_pin.sym} 560 2200 0 0 {name=l_n1067_g sig_type=std_logic lab=n1067_g}
C {devices/lab_pin.sym} 690 2200 0 0 {name=l_n1068_g sig_type=std_logic lab=n1068_g}
C {devices/lab_pin.sym} 300 2330 0 0 {name=l_n1069_g sig_type=std_logic lab=n1069_g}
C {devices/lab_pin.sym} 430 2330 0 0 {name=l_n1070_g sig_type=std_logic lab=n1070_g}
C {devices/lab_pin.sym} 560 2330 0 0 {name=l_n1071_g sig_type=std_logic lab=n1071_g}
C {devices/lab_pin.sym} 690 2330 0 0 {name=l_n1072_g sig_type=std_logic lab=n1072_g}
C {devices/lab_pin.sym} 300 2460 0 0 {name=l_n1073_g sig_type=std_logic lab=n1073_g}
C {devices/lab_pin.sym} 430 2460 0 0 {name=l_n1074_g sig_type=std_logic lab=n1074_g}
C {devices/lab_pin.sym} 560 2460 0 0 {name=l_n1075_g sig_type=std_logic lab=n1075_g}
C {devices/lab_pin.sym} 690 2460 0 0 {name=l_n1076_g sig_type=std_logic lab=n1076_g}
C {devices/lab_pin.sym} 300 2590 0 0 {name=l_n1077_g sig_type=std_logic lab=n1077_g}
C {devices/lab_pin.sym} 430 2590 0 0 {name=l_n1078_g sig_type=std_logic lab=n1078_g}
C {devices/lab_pin.sym} 560 2590 0 0 {name=l_n1079_g sig_type=std_logic lab=n1079_g}
C {devices/lab_pin.sym} 690 2590 0 0 {name=l_n1080_g sig_type=std_logic lab=n1080_g}
C {devices/lab_pin.sym} 300 2720 0 0 {name=l_n1081_g sig_type=std_logic lab=n1081_g}
C {devices/lab_pin.sym} 430 2720 0 0 {name=l_n1082_g sig_type=std_logic lab=n1082_g}
C {devices/lab_pin.sym} 560 2720 0 0 {name=l_n1083_g sig_type=std_logic lab=n1083_g}
C {devices/lab_pin.sym} 690 2720 0 0 {name=l_n1084_g sig_type=std_logic lab=n1084_g}
C {devices/lab_pin.sym} 300 2850 0 0 {name=l_n1085_g sig_type=std_logic lab=n1085_g}
C {devices/lab_pin.sym} 430 2850 0 0 {name=l_n1086_g sig_type=std_logic lab=n1086_g}
C {devices/lab_pin.sym} 560 2850 0 0 {name=l_n1087_g sig_type=std_logic lab=n1087_g}
C {devices/lab_pin.sym} 690 2850 0 0 {name=l_n1088_g sig_type=std_logic lab=n1088_g}
C {devices/lab_pin.sym} 300 2980 0 0 {name=l_n1089_g sig_type=std_logic lab=n1089_g}
C {devices/lab_pin.sym} 430 2980 0 0 {name=l_n1090_g sig_type=std_logic lab=n1090_g}
C {devices/lab_pin.sym} 560 2980 0 0 {name=l_n1091_g sig_type=std_logic lab=n1091_g}
C {devices/lab_pin.sym} 690 2980 0 0 {name=l_n1092_g sig_type=std_logic lab=n1092_g}
C {devices/lab_pin.sym} 300 3110 0 0 {name=l_n1093_g sig_type=std_logic lab=n1093_g}
C {devices/lab_pin.sym} 430 3110 0 0 {name=l_n1094_g sig_type=std_logic lab=n1094_g}
C {devices/lab_pin.sym} 560 3110 0 0 {name=l_n1095_g sig_type=std_logic lab=n1095_g}
C {devices/lab_pin.sym} 690 3110 0 0 {name=l_n1096_g sig_type=std_logic lab=n1096_g}
C {devices/lab_pin.sym} 300 3240 0 0 {name=l_n1097_g sig_type=std_logic lab=n1097_g}
C {devices/lab_pin.sym} 430 3240 0 0 {name=l_n1098_g sig_type=std_logic lab=n1098_g}
C {devices/lab_pin.sym} 560 3240 0 0 {name=l_n1099_g sig_type=std_logic lab=n1099_g}
C {devices/lab_pin.sym} 690 3240 0 0 {name=l_n1100_g sig_type=std_logic lab=n1100_g}
C {devices/lab_pin.sym} 300 3370 0 0 {name=l_n1101_g sig_type=std_logic lab=n1101_g}
C {devices/lab_pin.sym} 430 3370 0 0 {name=l_n1102_g sig_type=std_logic lab=n1102_g}
C {devices/lab_pin.sym} 560 3370 0 0 {name=l_n1103_g sig_type=std_logic lab=n1103_g}
C {devices/lab_pin.sym} 690 3370 0 0 {name=l_n1104_g sig_type=std_logic lab=n1104_g}
C {devices/lab_pin.sym} 300 3500 0 0 {name=l_n1105_g sig_type=std_logic lab=n1105_g}
C {devices/lab_pin.sym} 430 3500 0 0 {name=l_n1106_g sig_type=std_logic lab=n1106_g}
C {devices/lab_pin.sym} 560 3500 0 0 {name=l_n1107_g sig_type=std_logic lab=n1107_g}
C {devices/lab_pin.sym} 690 3500 0 0 {name=l_n1108_g sig_type=std_logic lab=n1108_g}
C {devices/lab_pin.sym} 300 3630 0 0 {name=l_n1109_g sig_type=std_logic lab=n1109_g}
C {devices/lab_pin.sym} 430 3630 0 0 {name=l_n1110_g sig_type=std_logic lab=n1110_g}
C {devices/lab_pin.sym} 560 3630 0 0 {name=l_n1111_g sig_type=std_logic lab=n1111_g}
C {devices/lab_pin.sym} 690 3630 0 0 {name=l_n1112_g sig_type=std_logic lab=n1112_g}
C {devices/lab_pin.sym} 300 3760 0 0 {name=l_n1113_g sig_type=std_logic lab=n1113_g}
C {devices/lab_pin.sym} 430 3760 0 0 {name=l_n1114_g sig_type=std_logic lab=n1114_g}
C {devices/lab_pin.sym} 560 3760 0 0 {name=l_n1115_g sig_type=std_logic lab=n1115_g}
C {devices/lab_pin.sym} 690 3760 0 0 {name=l_n1116_g sig_type=std_logic lab=n1116_g}
C {devices/lab_pin.sym} 300 3890 0 0 {name=l_n1117_g sig_type=std_logic lab=n1117_g}
C {devices/lab_pin.sym} 430 3890 0 0 {name=l_n1118_g sig_type=std_logic lab=n1118_g}
C {devices/lab_pin.sym} 560 3890 0 0 {name=l_n1119_g sig_type=std_logic lab=n1119_g}
C {devices/lab_pin.sym} 690 3890 0 0 {name=l_n1120_g sig_type=std_logic lab=n1120_g}
C {devices/lab_pin.sym} 300 4020 0 0 {name=l_n1121_g sig_type=std_logic lab=n1121_g}
C {devices/lab_pin.sym} 430 4020 0 0 {name=l_n1122_g sig_type=std_logic lab=n1122_g}
C {devices/lab_pin.sym} 560 4020 0 0 {name=l_n1123_g sig_type=std_logic lab=n1123_g}
C {devices/lab_pin.sym} 690 4020 0 0 {name=l_n1124_g sig_type=std_logic lab=n1124_g}
C {devices/lab_pin.sym} 300 4150 0 0 {name=l_n1125_g sig_type=std_logic lab=n1125_g}
C {devices/lab_pin.sym} 430 4150 0 0 {name=l_n1126_g sig_type=std_logic lab=n1126_g}
C {devices/lab_pin.sym} 560 4150 0 0 {name=l_n1127_g sig_type=std_logic lab=n1127_g}
C {devices/lab_pin.sym} 690 4150 0 0 {name=l_n1128_g sig_type=std_logic lab=n1128_g}
C {devices/lab_pin.sym} 300 4280 0 0 {name=l_n1129_g sig_type=std_logic lab=n1129_g}
C {devices/lab_pin.sym} 430 4280 0 0 {name=l_n1130_g sig_type=std_logic lab=n1130_g}
C {devices/lab_pin.sym} 560 4280 0 0 {name=l_n1131_g sig_type=std_logic lab=n1131_g}
C {devices/lab_pin.sym} 690 4280 0 0 {name=l_n1132_g sig_type=std_logic lab=n1132_g}
C {devices/lab_pin.sym} 300 4410 0 0 {name=l_n1133_g sig_type=std_logic lab=n1133_g}
C {devices/lab_pin.sym} 430 4410 0 0 {name=l_n1134_g sig_type=std_logic lab=n1134_g}
C {devices/lab_pin.sym} 560 4410 0 0 {name=l_n1135_g sig_type=std_logic lab=n1135_g}
C {devices/lab_pin.sym} 690 4410 0 0 {name=l_n1136_g sig_type=std_logic lab=n1136_g}
C {devices/lab_pin.sym} 300 4540 0 0 {name=l_n1137_g sig_type=std_logic lab=n1137_g}
C {devices/lab_pin.sym} 430 4540 0 0 {name=l_n1138_g sig_type=std_logic lab=n1138_g}
C {devices/lab_pin.sym} 560 4540 0 0 {name=l_n1139_g sig_type=std_logic lab=n1139_g}
C {devices/lab_pin.sym} 690 4540 0 0 {name=l_n1140_g sig_type=std_logic lab=n1140_g}
C {devices/lab_pin.sym} 300 4670 0 0 {name=l_n1141_g sig_type=std_logic lab=n1141_g}
C {devices/lab_pin.sym} 430 4670 0 0 {name=l_n1142_g sig_type=std_logic lab=n1142_g}
C {devices/lab_pin.sym} 560 4670 0 0 {name=l_n1143_g sig_type=std_logic lab=n1143_g}
C {devices/lab_pin.sym} 690 4670 0 0 {name=l_n1144_g sig_type=std_logic lab=n1144_g}
C {devices/lab_pin.sym} 300 4800 0 0 {name=l_n1145_g sig_type=std_logic lab=n1145_g}
C {devices/lab_pin.sym} 430 4800 0 0 {name=l_n1146_g sig_type=std_logic lab=n1146_g}
C {devices/lab_pin.sym} 560 4800 0 0 {name=l_n1147_g sig_type=std_logic lab=n1147_g}
C {devices/lab_pin.sym} 690 4800 0 0 {name=l_n1148_g sig_type=std_logic lab=n1148_g}
C {devices/lab_pin.sym} 300 4930 0 0 {name=l_n1149_g sig_type=std_logic lab=n1149_g}
C {devices/lab_pin.sym} 430 4930 0 0 {name=l_n1150_g sig_type=std_logic lab=n1150_g}
C {devices/lab_pin.sym} 560 4930 0 0 {name=l_n1151_g sig_type=std_logic lab=n1151_g}
C {devices/lab_pin.sym} 690 4930 0 0 {name=l_n1152_g sig_type=std_logic lab=n1152_g}
C {devices/lab_pin.sym} 300 5060 0 0 {name=l_n1153_g sig_type=std_logic lab=n1153_g}
C {devices/lab_pin.sym} 430 5060 0 0 {name=l_n42 sig_type=std_logic lab=n42}
C {devices/lab_pin.sym} 560 5060 0 0 {name=l_n1154_g sig_type=std_logic lab=n1154_g}
C {devices/lab_pin.sym} 690 5060 0 0 {name=l_n1155_g sig_type=std_logic lab=n1155_g}
