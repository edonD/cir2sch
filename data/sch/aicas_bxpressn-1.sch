v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {'bxpressn-1' check b parser} 250 30 0 0 0.5 0.5 {}
C {devices/vsource.sym} 300 150 0 0 {name=v1001_g
value='3'}
C {devices/vsource.sym} 430 150 0 0 {name=v1002_g
value='3'}
C {devices/vsource.sym} 560 150 0 0 {name=v1003_g
value='7'}
C {devices/vsource.sym} 690 150 0 0 {name=v1004_g
value='102'}
C {devices/vsource.sym} 820 150 0 0 {name=v1005_g
value='107'}
C {devices/vsource.sym} 950 150 0 0 {name=v1006_g
value='-1.1'}
C {devices/vsource.sym} 1080 150 0 0 {name=v1007_g
value='2'}
C {devices/vsource.sym} 1210 150 0 0 {name=v1008_g
value='4.5'}
C {devices/vsource.sym} 1340 150 0 0 {name=v1009_g
value='0'}
C {devices/vsource.sym} 1470 150 0 0 {name=v1010_g
value='0'}
C {devices/vsource.sym} 1600 150 0 0 {name=v1011_g
value='0'}
C {devices/vsource.sym} 1730 150 0 0 {name=v1012_g
value='1'}
C {devices/vsource.sym} 1860 150 0 0 {name=v1013_g
value='1'}
C {devices/vsource.sym} 1990 150 0 0 {name=v1014_g
value='0'}
C {devices/vsource.sym} 2120 150 0 0 {name=v1015_g
value='1'}
C {devices/vsource.sym} 2250 150 0 0 {name=v1016_g
value='1'}
C {devices/vsource.sym} 2380 150 0 0 {name=v1017_g
value='1'}
C {devices/vsource.sym} 2510 150 0 0 {name=v1018_g
value='1'}
C {devices/vsource.sym} 2640 150 0 0 {name=v1019_g
value='0'}
C {devices/vsource.sym} 2770 150 0 0 {name=v1020_g
value='0'}
C {devices/vsource.sym} 2900 150 0 0 {name=v1021_g
value='1'}
C {devices/vsource.sym} 3030 150 0 0 {name=v1022_g
value='0'}
C {devices/vsource.sym} 3160 150 0 0 {name=v1023_g
value='0'}
C {devices/vsource.sym} 3290 150 0 0 {name=v1024_g
value='0'}
C {devices/vsource.sym} 3420 150 0 0 {name=v1025_g
value='1'}
C {devices/vsource.sym} 3550 150 0 0 {name=v1026_g
value='0'}
C {devices/vsource.sym} 3680 150 0 0 {name=v1027_g
value='1'}
C {devices/vsource.sym} 3810 150 0 0 {name=v1028_g
value='0'}
C {devices/vsource.sym} 3940 150 0 0 {name=v1029_g
value='1'}
C {devices/vsource.sym} 4070 150 0 0 {name=v1030_g
value='0'}
C {devices/vsource.sym} 4200 150 0 0 {name=v1031_g
value='1'}
C {devices/vsource.sym} 4330 150 0 0 {name=v1032_g
value='1'}
C {devices/vsource.sym} 4460 150 0 0 {name=v1033_g
value='0'}
C {devices/vsource.sym} 4590 150 0 0 {name=v1034_g
value='0'}
C {devices/vsource.sym} 4720 150 0 0 {name=v1035_g
value='1'}
C {devices/vsource.sym} 4850 150 0 0 {name=v1036_g
value='1'}
C {devices/vsource.sym} 4980 150 0 0 {name=v1037_g
value='1'}
C {devices/vsource.sym} 5110 150 0 0 {name=v1038_g
value='0'}
C {devices/vsource.sym} 5240 150 0 0 {name=v1039_g
value='8'}
C {devices/vsource.sym} 5370 150 0 0 {name=v1040_g
value='8'}
C {devices/vsource.sym} 5500 150 0 0 {name=v1041_g
value='8'}
C {devices/vsource.sym} 5630 150 0 0 {name=v1042_g
value='8'}
C {devices/vsource.sym} 5760 150 0 0 {name=v1043_g
value='42'}
C {devices/vsource.sym} 5890 150 0 0 {name=v1044_g
value='42'}
C {devices/vsource.sym} 6020 150 0 0 {name=v1045_g
value='43'}
C {devices/vsource.sym} 6150 150 0 0 {name=v1046_g
value='42'}
C {devices/vsource.sym} 6280 150 0 0 {name=v1047_g
value='42'}
C {devices/vsource.sym} 6410 150 0 0 {name=v1048_g
value='41'}
C {devices/vsource.sym} 6540 150 0 0 {name=v1049_g
value='40'}
C {devices/vsource.sym} 6670 150 0 0 {name=v1050_g
value='0.2'}
C {devices/vsource.sym} 6800 150 0 0 {name=v1051_g
value='5'}
C {devices/vsource.sym} 6930 150 0 0 {name=v1052_g
value='42'}
C {devices/vsource.sym} 7060 150 0 0 {name=v1053_g
value='0.29552020666133955'}
C {devices/vsource.sym} 7190 150 0 0 {name=v1054_g
value='0.955336489125606'}
C {devices/vsource.sym} 7320 150 0 0 {name=v1055_g
value='0.30933624960962325'}
C {devices/vsource.sym} 7450 150 0 0 {name=v1056_g
value='0.3046926540153975'}
C {devices/vsource.sym} 7580 150 0 0 {name=v1057_g
value='1.266103672779499'}
C {devices/vsource.sym} 7710 150 0 0 {name=v1058_g
value='0.29145679447786704'}
C {devices/vsource.sym} 7840 150 0 0 {name=v1059_g
value='0.29145679447786704'}
C {devices/vsource.sym} 7970 150 0 0 {name=v1060_g
value='0.3045202934471426'}
C {devices/vsource.sym} 8100 150 0 0 {name=v1061_g
value='1.0453385141288605'}
C {devices/vsource.sym} 8230 150 0 0 {name=v1062_g
value='0.2913126124515909'}
C {devices/vsource.sym} 8360 150 0 0 {name=v1063_g
value='0.2956730475634223'}
C {devices/vsource.sym} 8490 150 0 0 {name=v1064_g
value='0.7564329108569595'}
C {devices/vsource.sym} 8620 150 0 0 {name=v1065_g
value='0.3095196042031116'}
C {devices/vsource.sym} 8750 150 0 0 {name=v1066_g
value='7.38905609893065'}
C {devices/vsource.sym} 8880 150 0 0 {name=v1067_g
value='0.1353352832366127'}
C {devices/vsource.sym} 9010 150 0 0 {name=v1068_g
value='0.6931471805599453'}
C {devices/vsource.sym} 9140 150 0 0 {name=v1069_g
value='-0.6931471805599453'}
C {devices/vsource.sym} 9270 150 0 0 {name=v1070_g
value='0.6931471805599453'}
C {devices/vsource.sym} 9400 150 0 0 {name=v1071_g
value='-0.6931471805599453'}
C {devices/vsource.sym} 9530 150 0 0 {name=v1072_g
value='1.4142135623730951'}
C {devices/vsource.sym} 9660 150 0 0 {name=v1073_g
value='4.0'}
C {devices/vsource.sym} 9790 150 0 0 {name=v1074_g
value='2'}
C {devices/vsource.sym} 9920 150 0 0 {name=v1075_g
value='2'}
C {devices/vsource.sym} 10050 150 0 0 {name=v1076_g
value='1'}
C {devices/vsource.sym} 10180 150 0 0 {name=v1077_g
value='0'}
C {devices/vsource.sym} 10310 150 0 0 {name=v1078_g
value='-1'}
C {devices/vsource.sym} 10440 150 0 0 {name=v1079_g
value='2'}
C {devices/vsource.sym} 10570 150 0 0 {name=v1080_g
value='1'}
C {devices/vsource.sym} 10700 150 0 0 {name=v1081_g
value='0'}
C {devices/vsource.sym} 10830 150 0 0 {name=v1082_g
value='-1'}
C {devices/vsource.sym} 10960 150 0 0 {name=v1083_g
value='-2'}
C {devices/vsource.sym} 11090 150 0 0 {name=v1084_g
value='3'}
C {devices/vsource.sym} 11220 150 0 0 {name=v1085_g
value='2'}
C {devices/vsource.sym} 11350 150 0 0 {name=v1086_g
value='2'}
C {devices/vsource.sym} 11480 150 0 0 {name=v1087_g
value='2'}
C {devices/vsource.sym} 11610 150 0 0 {name=v1088_g
value='2'}
C {devices/vsource.sym} 11740 150 0 0 {name=v1089_g
value='1'}
C {devices/vsource.sym} 11870 150 0 0 {name=v1090_g
value='1'}
C {devices/vsource.sym} 12000 150 0 0 {name=v1091_g
value='0'}
C {devices/vsource.sym} 12130 150 0 0 {name=v1092_g
value='0'}
C {devices/vsource.sym} 12260 150 0 0 {name=v1093_g
value='0'}
C {devices/vsource.sym} 12390 150 0 0 {name=v1094_g
value='0'}
C {devices/vsource.sym} 12520 150 0 0 {name=v1095_g
value='0'}
C {devices/vsource.sym} 12650 150 0 0 {name=v1096_g
value='-1'}
C {devices/vsource.sym} 12780 150 0 0 {name=v1097_g
value='-1'}
C {devices/vsource.sym} 12910 150 0 0 {name=v1098_g
value='-2'}
C {devices/vsource.sym} 13040 150 0 0 {name=v1099_g
value='-2'}
C {devices/vsource.sym} 13170 150 0 0 {name=v1100_g
value='-2'}
C {devices/vsource.sym} 13300 150 0 0 {name=v1101_g
value='-2'}
C {devices/vsource.sym} 13430 150 0 0 {name=v1102_g
value='-3'}
C {devices/vsource.sym} 13560 150 0 0 {name=v1103_g
value='2'}
C {devices/vsource.sym} 13690 150 0 0 {name=v1104_g
value='1'}
C {devices/vsource.sym} 13820 150 0 0 {name=v1105_g
value='0'}
C {devices/vsource.sym} 13950 150 0 0 {name=v1106_g
value='-2'}
C {devices/vsource.sym} 14080 150 0 0 {name=v1107_g
value='-3'}
C {devices/vsource.sym} 14210 150 0 0 {name=v1108_g
value='3'}
C {devices/vsource.sym} 14340 150 0 0 {name=v1109_g
value='2'}
C {devices/vsource.sym} 14470 150 0 0 {name=v1110_g
value='0'}
C {devices/vsource.sym} 14600 150 0 0 {name=v1111_g
value='-1'}
C {devices/vsource.sym} 14730 150 0 0 {name=v1112_g
value='-2'}
C {devices/vsource.sym} 14860 150 0 0 {name=v1113_g
value='1.1'}
C {devices/vsource.sym} 14990 150 0 0 {name=v1114_g
value='1.1'}
C {devices/vsource.sym} 15120 150 0 0 {name=v1115_g
value='2.1'}
C {devices/vsource.sym} 15250 150 0 0 {name=v1116_g
value='2.1'}
C {devices/vsource.sym} 15380 150 0 0 {name=v1117_g
value='1.0'}
C {devices/vsource.sym} 15510 150 0 0 {name=v1118_g
value='-0.3010299956639812'}
C {devices/vsource.sym} 15640 150 0 0 {name=v1119_g
value='1'}
C {devices/vsource.sym} 15770 150 0 0 {name=v1120_g
value='0.5'}
C {devices/vsource.sym} 15900 150 0 0 {name=v1121_g
value='0'}
C {devices/vsource.sym} 16030 150 0 0 {name=v1122_g
value='0.25'}
C {devices/vsource.sym} 16160 150 0 0 {name=v1123_g
value='0'}
C {devices/vsource.sym} 16290 150 0 0 {name=v1124_g
value='0'}
C {devices/vsource.sym} 16420 150 0 0 {name=v1125_g
value='-42'}
C {devices/vsource.sym} 16550 150 0 0 {name=v1126_g
value='0'}
C {devices/vsource.sym} 16680 150 0 0 {name=v1127_g
value='0'}
C {devices/vsource.sym} 16810 150 0 0 {name=v1128_g
value='0.25'}
C {devices/vsource.sym} 16940 150 0 0 {name=v1129_g
value='0.75'}
C {devices/vsource.sym} 17070 150 0 0 {name=v1130_g
value='1'}
C {devices/vsource.sym} 17200 150 0 0 {name=v1131_g
value='1'}
C {devices/vsource.sym} 17330 150 0 0 {name=v1132_g
value='-98'}
C {devices/vsource.sym} 17460 150 0 0 {name=v1133_g
value='2.5'}
C {devices/vsource.sym} 17590 150 0 0 {name=v1134_g
value='6'}
C {devices/vsource.sym} 17720 150 0 0 {name=v1135_g
value='97'}
C {devices/vsource.sym} 17850 150 0 0 {name=v1136_g
value='0'}
C {devices/vsource.sym} 17980 150 0 0 {name=v1137_g
value='1'}
C {devices/vsource.sym} 18110 150 0 0 {name=v1138_g
value='0'}
C {devices/vsource.sym} 18240 150 0 0 {name=v1139_g
value='1'}
C {devices/vsource.sym} 18370 150 0 0 {name=v1140_g
value='0'}
C {devices/vsource.sym} 18500 150 0 0 {name=v1141_g
value='1'}
C {devices/vsource.sym} 18630 150 0 0 {name=v1142_g
value='0'}
C {devices/vsource.sym} 18760 150 0 0 {name=v1143_g
value='0'}
C {devices/vsource.sym} 18890 150 0 0 {name=v1144_g
value='1'}
C {devices/vsource.sym} 19020 150 0 0 {name=v1145_g
value='1'}
C {devices/vsource.sym} 19150 150 0 0 {name=v1146_g
value='0'}
C {devices/vsource.sym} 19280 150 0 0 {name=v1147_g
value='0'}
C {devices/vsource.sym} 19410 150 0 0 {name=v1148_g
value='0'}
C {devices/vsource.sym} 19540 150 0 0 {name=v1149_g
value='1'}
C {devices/vsource.sym} 19670 150 0 0 {name=v1150_g
value='1'}
C {devices/vsource.sym} 19800 150 0 0 {name=v1151_g
value='1'}
C {devices/vsource.sym} 19930 150 0 0 {name=v1152_g
value='1'}
C {devices/vsource.sym} 20060 150 0 0 {name=v1153_g
value='0'}
C {devices/vsource.sym} 20190 150 0 0 {name=vaux1
value=42.0}
C {devices/vsource.sym} 20320 150 0 0 {name=v1154_g
value='42.0'}
C {devices/vsource.sym} 20450 150 0 0 {name=v1155_g
value='42.0'}
C {devices/lab_pin.sym} 300 120 0 0 {name=l_n1001_g sig_type=std_logic lab=n1001_g}
C {devices/gnd.sym} 300 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 430 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 560 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 690 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 820 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 950 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1080 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1210 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1340 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1470 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1600 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1730 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1860 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 1990 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 2120 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 2250 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 2380 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 2510 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 2640 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 2770 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 2900 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3030 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3160 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3290 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3420 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3550 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3680 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3810 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 3940 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4070 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4200 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4330 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4460 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4590 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4720 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4850 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 4980 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5110 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5240 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5370 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5500 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5630 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5760 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 5890 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6020 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6150 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6280 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6410 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6540 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6670 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6800 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 6930 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7060 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7190 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7320 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7450 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7580 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7710 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7840 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 7970 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 8100 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 8230 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 8360 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 8490 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 8620 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 8750 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 8880 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9010 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9140 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9270 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9400 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9530 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9660 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9790 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 9920 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10050 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10180 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10310 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10440 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10570 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10700 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10830 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 10960 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 11090 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 11220 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 11350 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 11480 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 11610 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 11740 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 11870 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12000 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12130 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12260 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12390 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12520 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12650 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12780 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 12910 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 13040 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 13170 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 13300 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 13430 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 13560 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 13690 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 13820 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 13950 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 14080 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 14210 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 14340 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 14470 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 14600 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 14730 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 14860 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 14990 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 15120 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 15250 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 15380 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 15510 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 15640 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 15770 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 15900 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 16030 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 16160 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 16290 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 16420 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 16550 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 16680 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 16810 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 16940 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 17070 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 17200 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 17330 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 17460 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 17590 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 17720 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 17850 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 17980 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 18110 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 18240 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 18370 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 18500 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 18630 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 18760 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 18890 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 19020 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 19150 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 19280 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 19410 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 19540 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 19670 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 19800 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 19930 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 20060 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 20190 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 20320 180 0 0 {name=l_0 lab=GND}
C {devices/gnd.sym} 20450 180 0 0 {name=l_0 lab=GND}
C {devices/lab_pin.sym} 430 120 0 0 {name=l_n1002_g sig_type=std_logic lab=n1002_g}
C {devices/lab_pin.sym} 560 120 0 0 {name=l_n1003_g sig_type=std_logic lab=n1003_g}
C {devices/lab_pin.sym} 690 120 0 0 {name=l_n1004_g sig_type=std_logic lab=n1004_g}
C {devices/lab_pin.sym} 820 120 0 0 {name=l_n1005_g sig_type=std_logic lab=n1005_g}
C {devices/lab_pin.sym} 950 120 0 0 {name=l_n1006_g sig_type=std_logic lab=n1006_g}
C {devices/lab_pin.sym} 1080 120 0 0 {name=l_n1007_g sig_type=std_logic lab=n1007_g}
C {devices/lab_pin.sym} 1210 120 0 0 {name=l_n1008_g sig_type=std_logic lab=n1008_g}
C {devices/lab_pin.sym} 1340 120 0 0 {name=l_n1009_g sig_type=std_logic lab=n1009_g}
C {devices/lab_pin.sym} 1470 120 0 0 {name=l_n1010_g sig_type=std_logic lab=n1010_g}
C {devices/lab_pin.sym} 1600 120 0 0 {name=l_n1011_g sig_type=std_logic lab=n1011_g}
C {devices/lab_pin.sym} 1730 120 0 0 {name=l_n1012_g sig_type=std_logic lab=n1012_g}
C {devices/lab_pin.sym} 1860 120 0 0 {name=l_n1013_g sig_type=std_logic lab=n1013_g}
C {devices/lab_pin.sym} 1990 120 0 0 {name=l_n1014_g sig_type=std_logic lab=n1014_g}
C {devices/lab_pin.sym} 2120 120 0 0 {name=l_n1015_g sig_type=std_logic lab=n1015_g}
C {devices/lab_pin.sym} 2250 120 0 0 {name=l_n1016_g sig_type=std_logic lab=n1016_g}
C {devices/lab_pin.sym} 2380 120 0 0 {name=l_n1017_g sig_type=std_logic lab=n1017_g}
C {devices/lab_pin.sym} 2510 120 0 0 {name=l_n1018_g sig_type=std_logic lab=n1018_g}
C {devices/lab_pin.sym} 2640 120 0 0 {name=l_n1019_g sig_type=std_logic lab=n1019_g}
C {devices/lab_pin.sym} 2770 120 0 0 {name=l_n1020_g sig_type=std_logic lab=n1020_g}
C {devices/lab_pin.sym} 2900 120 0 0 {name=l_n1021_g sig_type=std_logic lab=n1021_g}
C {devices/lab_pin.sym} 3030 120 0 0 {name=l_n1022_g sig_type=std_logic lab=n1022_g}
C {devices/lab_pin.sym} 3160 120 0 0 {name=l_n1023_g sig_type=std_logic lab=n1023_g}
C {devices/lab_pin.sym} 3290 120 0 0 {name=l_n1024_g sig_type=std_logic lab=n1024_g}
C {devices/lab_pin.sym} 3420 120 0 0 {name=l_n1025_g sig_type=std_logic lab=n1025_g}
C {devices/lab_pin.sym} 3550 120 0 0 {name=l_n1026_g sig_type=std_logic lab=n1026_g}
C {devices/lab_pin.sym} 3680 120 0 0 {name=l_n1027_g sig_type=std_logic lab=n1027_g}
C {devices/lab_pin.sym} 3810 120 0 0 {name=l_n1028_g sig_type=std_logic lab=n1028_g}
C {devices/lab_pin.sym} 3940 120 0 0 {name=l_n1029_g sig_type=std_logic lab=n1029_g}
C {devices/lab_pin.sym} 4070 120 0 0 {name=l_n1030_g sig_type=std_logic lab=n1030_g}
C {devices/lab_pin.sym} 4200 120 0 0 {name=l_n1031_g sig_type=std_logic lab=n1031_g}
C {devices/lab_pin.sym} 4330 120 0 0 {name=l_n1032_g sig_type=std_logic lab=n1032_g}
C {devices/lab_pin.sym} 4460 120 0 0 {name=l_n1033_g sig_type=std_logic lab=n1033_g}
C {devices/lab_pin.sym} 4590 120 0 0 {name=l_n1034_g sig_type=std_logic lab=n1034_g}
C {devices/lab_pin.sym} 4720 120 0 0 {name=l_n1035_g sig_type=std_logic lab=n1035_g}
C {devices/lab_pin.sym} 4850 120 0 0 {name=l_n1036_g sig_type=std_logic lab=n1036_g}
C {devices/lab_pin.sym} 4980 120 0 0 {name=l_n1037_g sig_type=std_logic lab=n1037_g}
C {devices/lab_pin.sym} 5110 120 0 0 {name=l_n1038_g sig_type=std_logic lab=n1038_g}
C {devices/lab_pin.sym} 5240 120 0 0 {name=l_n1039_g sig_type=std_logic lab=n1039_g}
C {devices/lab_pin.sym} 5370 120 0 0 {name=l_n1040_g sig_type=std_logic lab=n1040_g}
C {devices/lab_pin.sym} 5500 120 0 0 {name=l_n1041_g sig_type=std_logic lab=n1041_g}
C {devices/lab_pin.sym} 5630 120 0 0 {name=l_n1042_g sig_type=std_logic lab=n1042_g}
C {devices/lab_pin.sym} 5760 120 0 0 {name=l_n1043_g sig_type=std_logic lab=n1043_g}
C {devices/lab_pin.sym} 5890 120 0 0 {name=l_n1044_g sig_type=std_logic lab=n1044_g}
C {devices/lab_pin.sym} 6020 120 0 0 {name=l_n1045_g sig_type=std_logic lab=n1045_g}
C {devices/lab_pin.sym} 6150 120 0 0 {name=l_n1046_g sig_type=std_logic lab=n1046_g}
C {devices/lab_pin.sym} 6280 120 0 0 {name=l_n1047_g sig_type=std_logic lab=n1047_g}
C {devices/lab_pin.sym} 6410 120 0 0 {name=l_n1048_g sig_type=std_logic lab=n1048_g}
C {devices/lab_pin.sym} 6540 120 0 0 {name=l_n1049_g sig_type=std_logic lab=n1049_g}
C {devices/lab_pin.sym} 6670 120 0 0 {name=l_n1050_g sig_type=std_logic lab=n1050_g}
C {devices/lab_pin.sym} 6800 120 0 0 {name=l_n1051_g sig_type=std_logic lab=n1051_g}
C {devices/lab_pin.sym} 6930 120 0 0 {name=l_n1052_g sig_type=std_logic lab=n1052_g}
C {devices/lab_pin.sym} 7060 120 0 0 {name=l_n1053_g sig_type=std_logic lab=n1053_g}
C {devices/lab_pin.sym} 7190 120 0 0 {name=l_n1054_g sig_type=std_logic lab=n1054_g}
C {devices/lab_pin.sym} 7320 120 0 0 {name=l_n1055_g sig_type=std_logic lab=n1055_g}
C {devices/lab_pin.sym} 7450 120 0 0 {name=l_n1056_g sig_type=std_logic lab=n1056_g}
C {devices/lab_pin.sym} 7580 120 0 0 {name=l_n1057_g sig_type=std_logic lab=n1057_g}
C {devices/lab_pin.sym} 7710 120 0 0 {name=l_n1058_g sig_type=std_logic lab=n1058_g}
C {devices/lab_pin.sym} 7840 120 0 0 {name=l_n1059_g sig_type=std_logic lab=n1059_g}
C {devices/lab_pin.sym} 7970 120 0 0 {name=l_n1060_g sig_type=std_logic lab=n1060_g}
C {devices/lab_pin.sym} 8100 120 0 0 {name=l_n1061_g sig_type=std_logic lab=n1061_g}
C {devices/lab_pin.sym} 8230 120 0 0 {name=l_n1062_g sig_type=std_logic lab=n1062_g}
C {devices/lab_pin.sym} 8360 120 0 0 {name=l_n1063_g sig_type=std_logic lab=n1063_g}
C {devices/lab_pin.sym} 8490 120 0 0 {name=l_n1064_g sig_type=std_logic lab=n1064_g}
C {devices/lab_pin.sym} 8620 120 0 0 {name=l_n1065_g sig_type=std_logic lab=n1065_g}
C {devices/lab_pin.sym} 8750 120 0 0 {name=l_n1066_g sig_type=std_logic lab=n1066_g}
C {devices/lab_pin.sym} 8880 120 0 0 {name=l_n1067_g sig_type=std_logic lab=n1067_g}
C {devices/lab_pin.sym} 9010 120 0 0 {name=l_n1068_g sig_type=std_logic lab=n1068_g}
C {devices/lab_pin.sym} 9140 120 0 0 {name=l_n1069_g sig_type=std_logic lab=n1069_g}
C {devices/lab_pin.sym} 9270 120 0 0 {name=l_n1070_g sig_type=std_logic lab=n1070_g}
C {devices/lab_pin.sym} 9400 120 0 0 {name=l_n1071_g sig_type=std_logic lab=n1071_g}
C {devices/lab_pin.sym} 9530 120 0 0 {name=l_n1072_g sig_type=std_logic lab=n1072_g}
C {devices/lab_pin.sym} 9660 120 0 0 {name=l_n1073_g sig_type=std_logic lab=n1073_g}
C {devices/lab_pin.sym} 9790 120 0 0 {name=l_n1074_g sig_type=std_logic lab=n1074_g}
C {devices/lab_pin.sym} 9920 120 0 0 {name=l_n1075_g sig_type=std_logic lab=n1075_g}
C {devices/lab_pin.sym} 10050 120 0 0 {name=l_n1076_g sig_type=std_logic lab=n1076_g}
C {devices/lab_pin.sym} 10180 120 0 0 {name=l_n1077_g sig_type=std_logic lab=n1077_g}
C {devices/lab_pin.sym} 10310 120 0 0 {name=l_n1078_g sig_type=std_logic lab=n1078_g}
C {devices/lab_pin.sym} 10440 120 0 0 {name=l_n1079_g sig_type=std_logic lab=n1079_g}
C {devices/lab_pin.sym} 10570 120 0 0 {name=l_n1080_g sig_type=std_logic lab=n1080_g}
C {devices/lab_pin.sym} 10700 120 0 0 {name=l_n1081_g sig_type=std_logic lab=n1081_g}
C {devices/lab_pin.sym} 10830 120 0 0 {name=l_n1082_g sig_type=std_logic lab=n1082_g}
C {devices/lab_pin.sym} 10960 120 0 0 {name=l_n1083_g sig_type=std_logic lab=n1083_g}
C {devices/lab_pin.sym} 11090 120 0 0 {name=l_n1084_g sig_type=std_logic lab=n1084_g}
C {devices/lab_pin.sym} 11220 120 0 0 {name=l_n1085_g sig_type=std_logic lab=n1085_g}
C {devices/lab_pin.sym} 11350 120 0 0 {name=l_n1086_g sig_type=std_logic lab=n1086_g}
C {devices/lab_pin.sym} 11480 120 0 0 {name=l_n1087_g sig_type=std_logic lab=n1087_g}
C {devices/lab_pin.sym} 11610 120 0 0 {name=l_n1088_g sig_type=std_logic lab=n1088_g}
C {devices/lab_pin.sym} 11740 120 0 0 {name=l_n1089_g sig_type=std_logic lab=n1089_g}
C {devices/lab_pin.sym} 11870 120 0 0 {name=l_n1090_g sig_type=std_logic lab=n1090_g}
C {devices/lab_pin.sym} 12000 120 0 0 {name=l_n1091_g sig_type=std_logic lab=n1091_g}
C {devices/lab_pin.sym} 12130 120 0 0 {name=l_n1092_g sig_type=std_logic lab=n1092_g}
C {devices/lab_pin.sym} 12260 120 0 0 {name=l_n1093_g sig_type=std_logic lab=n1093_g}
C {devices/lab_pin.sym} 12390 120 0 0 {name=l_n1094_g sig_type=std_logic lab=n1094_g}
C {devices/lab_pin.sym} 12520 120 0 0 {name=l_n1095_g sig_type=std_logic lab=n1095_g}
C {devices/lab_pin.sym} 12650 120 0 0 {name=l_n1096_g sig_type=std_logic lab=n1096_g}
C {devices/lab_pin.sym} 12780 120 0 0 {name=l_n1097_g sig_type=std_logic lab=n1097_g}
C {devices/lab_pin.sym} 12910 120 0 0 {name=l_n1098_g sig_type=std_logic lab=n1098_g}
C {devices/lab_pin.sym} 13040 120 0 0 {name=l_n1099_g sig_type=std_logic lab=n1099_g}
C {devices/lab_pin.sym} 13170 120 0 0 {name=l_n1100_g sig_type=std_logic lab=n1100_g}
C {devices/lab_pin.sym} 13300 120 0 0 {name=l_n1101_g sig_type=std_logic lab=n1101_g}
C {devices/lab_pin.sym} 13430 120 0 0 {name=l_n1102_g sig_type=std_logic lab=n1102_g}
C {devices/lab_pin.sym} 13560 120 0 0 {name=l_n1103_g sig_type=std_logic lab=n1103_g}
C {devices/lab_pin.sym} 13690 120 0 0 {name=l_n1104_g sig_type=std_logic lab=n1104_g}
C {devices/lab_pin.sym} 13820 120 0 0 {name=l_n1105_g sig_type=std_logic lab=n1105_g}
C {devices/lab_pin.sym} 13950 120 0 0 {name=l_n1106_g sig_type=std_logic lab=n1106_g}
C {devices/lab_pin.sym} 14080 120 0 0 {name=l_n1107_g sig_type=std_logic lab=n1107_g}
C {devices/lab_pin.sym} 14210 120 0 0 {name=l_n1108_g sig_type=std_logic lab=n1108_g}
C {devices/lab_pin.sym} 14340 120 0 0 {name=l_n1109_g sig_type=std_logic lab=n1109_g}
C {devices/lab_pin.sym} 14470 120 0 0 {name=l_n1110_g sig_type=std_logic lab=n1110_g}
C {devices/lab_pin.sym} 14600 120 0 0 {name=l_n1111_g sig_type=std_logic lab=n1111_g}
C {devices/lab_pin.sym} 14730 120 0 0 {name=l_n1112_g sig_type=std_logic lab=n1112_g}
C {devices/lab_pin.sym} 14860 120 0 0 {name=l_n1113_g sig_type=std_logic lab=n1113_g}
C {devices/lab_pin.sym} 14990 120 0 0 {name=l_n1114_g sig_type=std_logic lab=n1114_g}
C {devices/lab_pin.sym} 15120 120 0 0 {name=l_n1115_g sig_type=std_logic lab=n1115_g}
C {devices/lab_pin.sym} 15250 120 0 0 {name=l_n1116_g sig_type=std_logic lab=n1116_g}
C {devices/lab_pin.sym} 15380 120 0 0 {name=l_n1117_g sig_type=std_logic lab=n1117_g}
C {devices/lab_pin.sym} 15510 120 0 0 {name=l_n1118_g sig_type=std_logic lab=n1118_g}
C {devices/lab_pin.sym} 15640 120 0 0 {name=l_n1119_g sig_type=std_logic lab=n1119_g}
C {devices/lab_pin.sym} 15770 120 0 0 {name=l_n1120_g sig_type=std_logic lab=n1120_g}
C {devices/lab_pin.sym} 15900 120 0 0 {name=l_n1121_g sig_type=std_logic lab=n1121_g}
C {devices/lab_pin.sym} 16030 120 0 0 {name=l_n1122_g sig_type=std_logic lab=n1122_g}
C {devices/lab_pin.sym} 16160 120 0 0 {name=l_n1123_g sig_type=std_logic lab=n1123_g}
C {devices/lab_pin.sym} 16290 120 0 0 {name=l_n1124_g sig_type=std_logic lab=n1124_g}
C {devices/lab_pin.sym} 16420 120 0 0 {name=l_n1125_g sig_type=std_logic lab=n1125_g}
C {devices/lab_pin.sym} 16550 120 0 0 {name=l_n1126_g sig_type=std_logic lab=n1126_g}
C {devices/lab_pin.sym} 16680 120 0 0 {name=l_n1127_g sig_type=std_logic lab=n1127_g}
C {devices/lab_pin.sym} 16810 120 0 0 {name=l_n1128_g sig_type=std_logic lab=n1128_g}
C {devices/lab_pin.sym} 16940 120 0 0 {name=l_n1129_g sig_type=std_logic lab=n1129_g}
C {devices/lab_pin.sym} 17070 120 0 0 {name=l_n1130_g sig_type=std_logic lab=n1130_g}
C {devices/lab_pin.sym} 17200 120 0 0 {name=l_n1131_g sig_type=std_logic lab=n1131_g}
C {devices/lab_pin.sym} 17330 120 0 0 {name=l_n1132_g sig_type=std_logic lab=n1132_g}
C {devices/lab_pin.sym} 17460 120 0 0 {name=l_n1133_g sig_type=std_logic lab=n1133_g}
C {devices/lab_pin.sym} 17590 120 0 0 {name=l_n1134_g sig_type=std_logic lab=n1134_g}
C {devices/lab_pin.sym} 17720 120 0 0 {name=l_n1135_g sig_type=std_logic lab=n1135_g}
C {devices/lab_pin.sym} 17850 120 0 0 {name=l_n1136_g sig_type=std_logic lab=n1136_g}
C {devices/lab_pin.sym} 17980 120 0 0 {name=l_n1137_g sig_type=std_logic lab=n1137_g}
C {devices/lab_pin.sym} 18110 120 0 0 {name=l_n1138_g sig_type=std_logic lab=n1138_g}
C {devices/lab_pin.sym} 18240 120 0 0 {name=l_n1139_g sig_type=std_logic lab=n1139_g}
C {devices/lab_pin.sym} 18370 120 0 0 {name=l_n1140_g sig_type=std_logic lab=n1140_g}
C {devices/lab_pin.sym} 18500 120 0 0 {name=l_n1141_g sig_type=std_logic lab=n1141_g}
C {devices/lab_pin.sym} 18630 120 0 0 {name=l_n1142_g sig_type=std_logic lab=n1142_g}
C {devices/lab_pin.sym} 18760 120 0 0 {name=l_n1143_g sig_type=std_logic lab=n1143_g}
C {devices/lab_pin.sym} 18890 120 0 0 {name=l_n1144_g sig_type=std_logic lab=n1144_g}
C {devices/lab_pin.sym} 19020 120 0 0 {name=l_n1145_g sig_type=std_logic lab=n1145_g}
C {devices/lab_pin.sym} 19150 120 0 0 {name=l_n1146_g sig_type=std_logic lab=n1146_g}
C {devices/lab_pin.sym} 19280 120 0 0 {name=l_n1147_g sig_type=std_logic lab=n1147_g}
C {devices/lab_pin.sym} 19410 120 0 0 {name=l_n1148_g sig_type=std_logic lab=n1148_g}
C {devices/lab_pin.sym} 19540 120 0 0 {name=l_n1149_g sig_type=std_logic lab=n1149_g}
C {devices/lab_pin.sym} 19670 120 0 0 {name=l_n1150_g sig_type=std_logic lab=n1150_g}
C {devices/lab_pin.sym} 19800 120 0 0 {name=l_n1151_g sig_type=std_logic lab=n1151_g}
C {devices/lab_pin.sym} 19930 120 0 0 {name=l_n1152_g sig_type=std_logic lab=n1152_g}
C {devices/lab_pin.sym} 20060 120 0 0 {name=l_n1153_g sig_type=std_logic lab=n1153_g}
C {devices/lab_pin.sym} 20190 120 0 0 {name=l_n42 sig_type=std_logic lab=n42}
C {devices/lab_pin.sym} 20320 120 0 0 {name=l_n1154_g sig_type=std_logic lab=n1154_g}
C {devices/lab_pin.sym} 20450 120 0 0 {name=l_n1155_g sig_type=std_logic lab=n1155_g}
