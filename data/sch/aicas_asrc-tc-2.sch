** sch_path: data/sch/aicas_asrc-tc-2.sch
**.subckt aicas_asrc-tc-2
r2 net1 2 1k m=1
r3 net1 3 r m=1
**.ends
.end
