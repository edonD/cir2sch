v {xschem version=3.4.5 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {port: a1 IN} 390 -465 0 0 0.35 0.35 {}
T {port: a2 IN} 390 -440 0 0 0.35 0.35 {}
T {port: a3 IN} 390 -415 0 0 0.35 0.35 {}
C {devices/capa.sym} 440 -280 0 0 {name=Componenet
value=:}
C {283.sym} 660 -300 0 0 {name=X1}
T {X1} 640 -280 0 0 0.25 0.25 {}
C {devices/lab_pin.sym} 440 -310 0 0 {name=l_type sig_type=std_logic lab=type}
C {devices/lab_pin.sym} 440 -250 0 0 {name=l_283 sig_type=std_logic lab=283}
C {devices/lab_pin.sym} 630 -360 0 0 {name=l_a1 sig_type=std_logic lab=a1}
C {devices/lab_pin.sym} 690 -360 0 0 {name=l_a2 sig_type=std_logic lab=a2}
C {devices/lab_pin.sym} 630 -340 0 0 {name=l_a3 sig_type=std_logic lab=a3}
C {devices/lab_pin.sym} 690 -340 0 0 {name=l_a4 sig_type=std_logic lab=a4}
C {devices/lab_pin.sym} 630 -320 0 0 {name=l_b1 sig_type=std_logic lab=b1}
C {devices/lab_pin.sym} 690 -320 0 0 {name=l_b2 sig_type=std_logic lab=b2}
C {devices/lab_pin.sym} 630 -300 0 0 {name=l_b3 sig_type=std_logic lab=b3}
C {devices/lab_pin.sym} 690 -300 0 0 {name=l_b4 sig_type=std_logic lab=b4}
C {devices/lab_pin.sym} 630 -280 0 0 {name=l_c0 sig_type=std_logic lab=c0}
C {devices/lab_pin.sym} 690 -280 0 0 {name=l_sigma1 sig_type=std_logic lab=sigma1}
C {devices/lab_pin.sym} 630 -260 0 0 {name=l_sigma2 sig_type=std_logic lab=sigma2}
C {devices/lab_pin.sym} 690 -260 0 0 {name=l_sigma3 sig_type=std_logic lab=sigma3}
C {devices/lab_pin.sym} 630 -240 0 0 {name=l_sigma4 sig_type=std_logic lab=sigma4}
C {devices/lab_pin.sym} 690 -240 0 0 {name=l_c4 sig_type=std_logic lab=c4}
